# Keil uVision project vsf_template.uvprojx, settings and files
target mps2 (6160000::V6.16::ARMCLANG)
  device: CMSDK_CM7 ARM
  pack: Keil.V2M-MPS2_CMx_BSP.1.7.1
  cpu: IRAM(0x20000000,0x00400000) IROM(0x00000000,0x00400000) CPUTYPE("Cortex-M7") CLOCK(12000000) ELITTLE
  output: vsf_template
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=4 v6LangP=3 v6Lto=1 wLevel=3
  c define: __ARM__, __MPS2__, __OOC_CPP__, LV_CONF_INCLUDE_SIMPLE, FT2_BUILD_LIBRARY
  c misc: -fms-extensions  -Wno-enum-conversion -Wno-empty-body  -Wno-initializer-overrides -Wno-microsoft-anon-tag -Wno-nonportable-include-path -Wno-tautological-constant-out-of-range-compare
  c include: ..\..\config;..\..\config\3rd-party\lvgl;..\..\..\..\source;..\..\..\..\source\shell\sys\linux\kernel\fs\vfs\files\terminfo;..\..\..\..\source\shell\sys\linux\include;..\..\..\..\source\shell\sys\linux\include\simple_libc;..\..\..\..\source\utilities\compiler\arm\3rd-party\CMSIS\CMSIS\Core\Include;..\..\..\..\source\component\3rd-party\nnom\raw\inc;..\..\..\..\source\component\3rd-party\vsfvm\raw;..\..\..\..\source\component\3rd-party\lvgl\raw;..\..\..\..\source\component\3rd-party\segger\raw\RTT;..\..\..\..\source\component\3rd-party\segger\raw\SystemView;..\..\..\..\source\component\3rd-party\segger\port\Config;..\..\..\..\source\component\3rd-party\LingLongGUI\port;..\..\..\..\source\component\3rd-party\LingLongGUI\raw\Gui;..\..\..\..\source\component\3rd-party\freetype\port;..\..\..\..\source\component\3rd-party\freetype\raw\include;..\..\..\..\source\component\3rd-party\coremark\port;..\..\..\..\source\component\3rd-party\coremark\raw;..\..\..\..\source\component\3rd-party\lua\extension\oo;..\..\..\..\source\component\3rd-party\lua\extension\lovevsf;..\..\..\..\source\component\3rd-party\lua\raw;..\..\..\..\source\component\3rd-party\libjpeg-turbo\port;..\..\..\..\source\component\3rd-party\libjpeg-turbo\raw;..\..\..\..\source\component\3rd-party\libpng\port;..\..\..\..\source\component\3rd-party\libpng\raw;..\..\..\..\source\component\3rd-party\zlib\raw
  asm misc: --cpreproc --cpreproc_opts=-D_MSC_VER,-D__ARM__,-D__MPS2__
  memory RVCT4: ROM 0x0 size 0x400000
  memory RVCT9: RAM 0x20000000 size 0x400000
  scatter file: .\vsf_template.sct
  group example/template/config
    ../../../../example/template/config/: vsf_tgui_cfg.h vsf_tgui_designer_cfg.h vsf_usr_cfg.h
  group example/template/config/3rd-party/awtk
    ../../../../../vsf-all-in-one/example/template/config/3rd-party/awtk/: awtk_config.h
  group example/template/config/3rd-party/btstack
    ../../../../../vsf-all-in-one/example/template/config/3rd-party/btstack/: btstack_config.h
  group example/template/config/3rd-party/evm
    ../../../../../vsf-all-in-one/example/template/config/3rd-party/evm/: evm_lua_conf.h
  group example/template/config/3rd-party/lvgl
    ../../../../../vsf-all-in-one/example/template/config/3rd-party/lvgl/: lv_conf.h
  group example/template/config/3rd-party/lwip
    ../../../../../vsf-all-in-one/example/template/config/3rd-party/lwip/: lwipopts.h
  group example/template/config/3rd-party/mbedtls
    ../../../../../vsf-all-in-one/example/template/config/3rd-party/mbedtls/: config.h
  group example/template/config/vsf_usr_cfg
    ../../../../example/template/config/vsf_usr_cfg/: vsf_usr_cfg_aic8800.h vsf_usr_cfg_esp32.h vsf_usr_cfg_esp32s2.h vsf_usr_cfg_f1c100s.h vsf_usr_cfg_gd32e103.h vsf_usr_cfg_linux.h vsf_usr_cfg_m484.h vsf_usr_cfg_mps2.h vsf_usr_cfg_mt071.h vsf_usr_cfg_win.h
    ../../config/vsf_usr_cfg/: vsf_usr_cfg_cmem7.h
  group example/template/demo
    ../../../../example/template/demo/: fakefat32.c fakefat32.h
  group example/template/demo/LingLongGUI_demo
    ../../../../example/template/demo/LingLongGUI_demo/: llgui_demo.c
  group example/template/demo/LingLongGUI_demo/application
    ../../../../example/template/demo/LingLongGUI_demo/application/: LL_User.c LL_User.h ui_ll_application.c ui_ll_application.h ui_ll_applicationLogic.c ui_ll_applicationLogic.h
  group example/template/demo/LingLongGUI_demo/application/Fonts
    ../../../../example/template/demo/LingLongGUI_demo/application/Fonts/: SimSun_9.c SimSun_9.h
  group example/template/demo/audio_demo
    ../../../../example/template/demo/audio_demo/: audio_demo.c
  group example/template/demo/btstack_demo
    ../../../../example/template/demo/btstack_demo/: btstack_application.c btstack_demo.c
  group example/template/demo/common
    ../../../../example/template/demo/common/: usrapp_audio_common.c usrapp_audio_common.h usrapp_common.c usrapp_common.h usrapp_net_common.c usrapp_net_common.h usrapp_ui_common.c usrapp_ui_common.h usrapp_usbd_common.c usrapp_usbd_common.h usrapp_usbh_common.c usrapp_usbh_common.h
  group example/template/demo/cpp_demo
    ../../../../example/template/demo/cpp_demo/: cpp_demo.cpp
  group example/template/demo/cpu_usage_demo
    ../../demo/cpu_usage_demo/: cpu_usage_demo.c
  group example/template/demo/disp_demo
    ../../../../example/template/demo/disp_demo/: disp_demo.c
  group example/template/demo/distbus_demo
    ../../../../example/template/demo/distbus_demo/: distbus_demo.c
  group example/template/demo/distbus_demo/app
    ../../../../example/template/demo/distbus_demo/app/: distbus_hal.c
  group example/template/demo/distbus_demo/bus
    ../../../../example/template/demo/distbus_demo/bus/: distbus_lwip.c distbus_usart.c
  group example/template/demo/freetype_demo
    ../../../../example/template/demo/freetype_demo/: freetype_demo.c
  group example/template/demo/hal_demo
    ../../../../example/template/demo/hal_demo/: usart_demo.c
    ../../demo/hal_demo/: adc_demo.c flash_demo.c gpio_demo.c i2c_demo.c pwm_demo.c rtc_demo.c spi_demo.c timer_demo.c
  group example/template/demo/json_demo
    ../../../../example/template/demo/json_demo/: json_demo.c
  group example/template/demo/kernel_test
    ../../../../example/template/demo/kernel_test/: cross_task_test.c eda_test.c fsm_test.c sem_test.c
  group example/template/demo/linux_demo
    ../../../../example/template/demo/linux_demo/: libusb_demo.c linux_demo.c
    ../../demo/linux_demo/: httpd_demo.c mount_demo.c ntpdate_demo.c telnetd_demo.c
  group example/template/demo/lua_demo
    ../../../../example/template/demo/lua_demo/: love_demo.c
  group example/template/demo/lvgl_demo
    ../../../../example/template/demo/lvgl_demo/: lvgl_application.c lvgl_demo.c lvgl_terminal_application.c
  group example/template/demo/lwip_demo
    ../../../../example/template/demo/lwip_demo/: lwip_demo.c
  group example/template/demo/nnom_demo
    ../../../../example/template/demo/nnom_demo/: nnom_demo.c
  group example/template/demo/nnom_demo/model/mnist
    ../../../../example/template/demo/nnom_demo/model/mnist/: image.h weights.h
  group example/template/demo/nuklear_demo
    ../../../../example/template/demo/nuklear_demo/: main.c sdl2surface_rawfb.h
  group example/template/demo/scsi_demo
    ../../../../example/template/demo/scsi_demo/: scsi_demo.c
  group example/template/demo/sdl2_demo
    ../../../../example/template/demo/sdl2_demo/: sdl2_demo.c
  group example/template/demo/socket_demo
    ../../../../example/template/demo/socket_demo/: socket_demo.c
  group example/template/demo/stream_hal_demo
    ../../../../example/template/demo/stream_hal_demo/: stream_usart_demo.c
  group example/template/demo/tgui_demo
    ../../../../example/template/demo/tgui_demo/: tgui_main.c
  group example/template/demo/tgui_demo/tgui_demo
    ../../../../example/template/demo/tgui_demo/tgui_demo/: tgui_custom.c tgui_custom.h tgui_demo.c tgui_port.c
  group example/template/demo/tgui_demo/tgui_demo/images
    ../../../../example/template/demo/tgui_demo/tgui_demo/images/: demo_images.c demo_images.h demo_images_data.h
  group example/template/demo/tgui_demo/tgui_demo/stopwatch
    ../../../../example/template/demo/tgui_demo/tgui_demo/stopwatch/: stopwatch.c stopwatch.h
  group example/template/demo/tgui_demo/tgui_demo/tgui_designer
    ../../../../example/template/demo/tgui_demo/tgui_demo/tgui_designer/: tgui_control_create.c tgui_control_create.h tgui_control_tree_dump.c tgui_control_tree_dump.h tgui_designer.c tgui_designer.h tgui_designer_common.c tgui_designer_common.h
  group example/template/demo/usbd_demo
    ../../../../example/template/demo/usbd_demo/: usbd_demo_cdc.c usbd_demo_msc.c usbd_demo_uac.c usbd_demo_user.c usbd_demo_uvc.c
  group example/template/demo/usbh_demo
    ../../../../example/template/demo/usbh_demo/: usbh_demo.c
  group example/template/demo/vsfip_demo
    ../../../../example/template/demo/vsfip_demo/: vsfip_demo.c
  group example/template/demo/vsfvm_demo
    ../../../../example/template/demo/vsfvm_demo/: vsfvm_demo.c
  group source
    ../../../../source/: vsf.h vsf_cfg.h
  group source/component
    ../../../../source/component/: vsf_component.c vsf_component.h vsf_component_cfg.h
  group source/component/3rd-party/LingLongGUI/port
    ../../../../source/component/3rd-party/LingLongGUI/port/: LL_Config.c LL_Config.h
  group source/component/3rd-party/LingLongGUI/raw
    ../../../../source/component/3rd-party/LingLongGUI/raw/: LL_Config_S028H32240_01.c LL_Config_S028H32240_01.h LL_Config_S043H480272_05.c LL_Config_S043H480272_05.h LL_Config_SDL.c LL_Config_SDL.h LL_Config_template.c LL_Config_template.h
  group source/component/3rd-party/LingLongGUI/raw/Gui
    ../../../../source/component/3rd-party/LingLongGUI/raw/Gui/: LL_Background.c LL_Background.h LL_Button.c LL_Button.h LL_ButtonEx.c LL_ButtonEx.h LL_CheckBox.c LL_CheckBox.h LL_ComboBox.c LL_ComboBox.h LL_DateTime.c LL_DateTime.h LL_Gauge.c LL_Gauge.h LL_General.c LL_General.h LL_Graph.c LL_Graph.h LL_Handler.c LL_Handler.h LL_IconSlider.c LL_IconSlider.h LL_Image.c LL_Image.h LL_Keyboard.c LL_Keyboard.h LL_LineEdit.c LL_LineEdit.h LL_ProgressBar.c LL_ProgressBar.h LL_QRCode.c LL_QRCode.h LL_Slider.c LL_Slider.h LL_Text.c LL_Text.h LL_Window.c LL_Window.h
  group source/component/3rd-party/LingLongGUI/raw/Misc
    ../../../../source/component/3rd-party/LingLongGUI/raw/Misc/: LL_Characters.c LL_Characters.h LL_Font.c LL_Font.h LL_Lattice.c LL_Lattice.h LL_Linked_List.c LL_Linked_List.h LL_Port.c LL_Port.h LL_Queue.c LL_Queue.h LL_String.c LL_String.h LL_Timer.c LL_Timer.h asciiDefine.h freeRtosHeap4.c freeRtosHeap4.h qrcodegen.c qrcodegen.h
  group source/component/3rd-party/awtk/port
    ../../../../source/component/3rd-party/awtk/port/: vsf_awtk_port.c vsf_awtk_port.h
  group source/component/3rd-party/awtk/port/platforms/vsf
    ../../../../source/component/3rd-party/awtk/port/platforms/vsf/: fs_os.c main_loop_vsf.c main_loop_vsf.h mutex.c platform.c semaphore.c thread.c
  group source/component/3rd-party/coremark/port
    ../../../../source/component/3rd-party/coremark/port/: core_portme.c core_portme.h
  group source/component/3rd-party/coremark/raw
    ../../../../source/component/3rd-party/coremark/raw/: core_list_join.c core_main.c core_matrix.c core_state.c core_util.c coremark.h
  group source/component/3rd-party/freetype/raw/include
    ../../../../source/component/3rd-party/freetype/raw/include/: ft2build.h
  group source/component/3rd-party/freetype/raw/include/freetype
    ../../../../source/component/3rd-party/freetype/raw/include/freetype/: freetype.h ftadvanc.h ftbbox.h ftbdf.h ftbitmap.h ftbzip2.h ftcache.h ftchapters.h ftcid.h ftcolor.h ftdriver.h fterrdef.h fterrors.h ftfntfmt.h ftgasp.h ftglyph.h ftgxval.h ftgzip.h ftimage.h ftincrem.h ftlcdfil.h ftlist.h ftlzw.h ftmac.h ftmm.h ftmodapi.h ftmoderr.h ftotval.h ftoutln.h ftparams.h ftpfr.h ftrender.h ftsizes.h ftsnames.h ftstroke.h ftsynth.h ftsystem.h fttrigon.h fttypes.h ftwinfnt.h t1tables.h ttnameid.h tttables.h tttags.h
  group source/component/3rd-party/freetype/raw/include/freetype/config
    ../../../../source/component/3rd-party/freetype/raw/include/freetype/config/: ftconfig.h ftheader.h ftmodule.h ftoption.h ftstdlib.h
  group source/component/3rd-party/freetype/raw/include/freetype/internal
    ../../../../source/component/3rd-party/freetype/raw/include/freetype/internal/: autohint.h cffotypes.h cfftypes.h ftcalc.h ftdebug.h ftdrv.h ftgloadr.h fthash.h ftmemory.h ftobjs.h ftpsprop.h ftrfork.h ftserv.h ftstream.h fttrace.h ftvalid.h internal.h psaux.h pshints.h sfnt.h t1types.h tttypes.h wofftypes.h
  group source/component/3rd-party/freetype/raw/include/freetype/internal/services
    ../../../../source/component/3rd-party/freetype/raw/include/freetype/internal/services/: svbdf.h svcfftl.h svcid.h svfntfmt.h svgldict.h svgxval.h svkern.h svmetric.h svmm.h svotval.h svpfr.h svpostnm.h svprop.h svpscmap.h svpsinfo.h svsfnt.h svttcmap.h svtteng.h svttglyf.h svwinfnt.h
  group source/component/3rd-party/freetype/raw/src/autofit
    ../../../../source/component/3rd-party/freetype/raw/src/autofit/: afangles.c afangles.h afblue.c afblue.h afcjk.c afcjk.h afcover.h afdummy.c afdummy.h aferrors.h afglobal.c afglobal.h afhints.c afhints.h afindic.c afindic.h aflatin.c aflatin.h aflatin2.c aflatin2.h afloader.c afloader.h afmodule.c afmodule.h afranges.c afranges.h afscript.h afshaper.c afshaper.h afstyles.h aftypes.h afwarp.c afwarp.h afwrtsys.h autofit.c
  group source/component/3rd-party/freetype/raw/src/base
    ../../../../source/component/3rd-party/freetype/raw/src/base/: ftadvanc.c ftbase.c ftbase.h ftbbox.c ftbdf.c ftbitmap.c ftcalc.c ftcid.c ftcolor.c ftdbgmem.c ftdebug.c fterrors.c ftfntfmt.c ftfstype.c ftgasp.c ftgloadr.c ftglyph.c ftgxval.c fthash.c ftinit.c ftlcdfil.c ftmac.c ftmm.c ftobjs.c ftotval.c ftoutln.c ftpatent.c ftpfr.c ftpsprop.c ftrfork.c ftsnames.c ftstream.c ftstroke.c ftsynth.c ftsystem.c fttrigon.c fttype1.c ftutil.c ftwinfnt.c md5.c md5.h
  group source/component/3rd-party/freetype/raw/src/bdf
    ../../../../source/component/3rd-party/freetype/raw/src/bdf/: bdf.c bdf.h bdfdrivr.c bdfdrivr.h bdferror.h bdflib.c
  group source/component/3rd-party/freetype/raw/src/bzip2
    ../../../../source/component/3rd-party/freetype/raw/src/bzip2/: ftbzip2.c
  group source/component/3rd-party/freetype/raw/src/cache
    ../../../../source/component/3rd-party/freetype/raw/src/cache/: ftcache.c ftcbasic.c ftccache.c ftccache.h ftccback.h ftccmap.c ftcerror.h ftcglyph.c ftcglyph.h ftcimage.c ftcimage.h ftcmanag.c ftcmanag.h ftcmru.c ftcmru.h ftcsbits.c ftcsbits.h
  group source/component/3rd-party/freetype/raw/src/cff
    ../../../../source/component/3rd-party/freetype/raw/src/cff/: cff.c cffcmap.c cffcmap.h cffdrivr.c cffdrivr.h cfferrs.h cffgload.c cffgload.h cffload.c cffload.h cffobjs.c cffobjs.h cffparse.c cffparse.h cfftoken.h
  group source/component/3rd-party/freetype/raw/src/cid
    ../../../../source/component/3rd-party/freetype/raw/src/cid/: ciderrs.h cidgload.c cidgload.h cidload.c cidload.h cidobjs.c cidobjs.h cidparse.c cidparse.h cidriver.c cidriver.h cidtoken.h type1cid.c
  group source/component/3rd-party/freetype/raw/src/gxvalid
    ../../../../source/component/3rd-party/freetype/raw/src/gxvalid/: gxvalid.c gxvalid.h gxvbsln.c gxvcommn.c gxvcommn.h gxverror.h gxvfeat.c gxvfeat.h gxvfgen.c gxvjust.c gxvkern.c gxvlcar.c gxvmod.c gxvmod.h gxvmort.c gxvmort.h gxvmort0.c gxvmort1.c gxvmort2.c gxvmort4.c gxvmort5.c gxvmorx.c gxvmorx.h gxvmorx0.c gxvmorx1.c gxvmorx2.c gxvmorx4.c gxvmorx5.c gxvopbd.c gxvprop.c gxvtrak.c
  group source/component/3rd-party/freetype/raw/src/gzip
    ../../../../source/component/3rd-party/freetype/raw/src/gzip/: adler32.c ftgzip.c ftzconf.h infblock.c infblock.h infcodes.c infcodes.h inffixed.h inflate.c inftrees.c inftrees.h infutil.c infutil.h zlib.h zutil.c zutil.h
  group source/component/3rd-party/freetype/raw/src/lzw
    ../../../../source/component/3rd-party/freetype/raw/src/lzw/: ftlzw.c ftzopen.c ftzopen.h
  group source/component/3rd-party/freetype/raw/src/otvalid
    ../../../../source/component/3rd-party/freetype/raw/src/otvalid/: otvalid.c otvalid.h otvbase.c otvcommn.c otvcommn.h otverror.h otvgdef.c otvgpos.c otvgpos.h otvgsub.c otvjstf.c otvmath.c otvmod.c otvmod.h
  group source/component/3rd-party/freetype/raw/src/pcf
    ../../../../source/component/3rd-party/freetype/raw/src/pcf/: pcf.c pcf.h pcfdrivr.c pcfdrivr.h pcferror.h pcfread.c pcfread.h pcfutil.c pcfutil.h
  group source/component/3rd-party/freetype/raw/src/pfr
    ../../../../source/component/3rd-party/freetype/raw/src/pfr/: pfr.c pfrcmap.c pfrcmap.h pfrdrivr.c pfrdrivr.h pfrerror.h pfrgload.c pfrgload.h pfrload.c pfrload.h pfrobjs.c pfrobjs.h pfrsbit.c pfrsbit.h pfrtypes.h
  group source/component/3rd-party/freetype/raw/src/psaux
    ../../../../source/component/3rd-party/freetype/raw/src/psaux/: afmparse.c afmparse.h cffdecode.c cffdecode.h psarrst.c psarrst.h psaux.c psauxerr.h psauxmod.c psauxmod.h psblues.c psblues.h psconv.c psconv.h pserror.c pserror.h psfixed.h psfont.c psfont.h psft.c psft.h psglue.h pshints.c pshints.h psintrp.c psintrp.h psobjs.c psobjs.h psread.c psread.h psstack.c psstack.h pstypes.h t1cmap.c t1cmap.h t1decode.c t1decode.h
  group source/component/3rd-party/freetype/raw/src/pshinter
    ../../../../source/component/3rd-party/freetype/raw/src/pshinter/: pshalgo.c pshalgo.h pshglob.c pshglob.h pshinter.c pshmod.c pshmod.h pshnterr.h pshrec.c pshrec.h
  group source/component/3rd-party/freetype/raw/src/psnames
    ../../../../source/component/3rd-party/freetype/raw/src/psnames/: psmodule.c psmodule.h psnamerr.h psnames.c pstables.h
  group source/component/3rd-party/freetype/raw/src/raster
    ../../../../source/component/3rd-party/freetype/raw/src/raster/: ftmisc.h ftraster.c ftraster.h ftrend1.c ftrend1.h raster.c rasterrs.h
  group source/component/3rd-party/freetype/raw/src/sfnt
    ../../../../source/component/3rd-party/freetype/raw/src/sfnt/: pngshim.c pngshim.h sfdriver.c sfdriver.h sferrors.h sfnt.c sfobjs.c sfobjs.h sfwoff.c sfwoff.h ttbdf.c ttbdf.h ttcmap.c ttcmap.h ttcmapc.h ttcolr.c ttcolr.h ttcpal.c ttcpal.h ttkern.c ttkern.h ttload.c ttload.h ttmtx.c ttmtx.h ttpost.c ttpost.h ttsbit.c ttsbit.h
  group source/component/3rd-party/freetype/raw/src/smooth
    ../../../../source/component/3rd-party/freetype/raw/src/smooth/: ftgrays.c ftgrays.h ftsmerrs.h ftsmooth.c ftsmooth.h smooth.c
  group source/component/3rd-party/freetype/raw/src/tools
    ../../../../source/component/3rd-party/freetype/raw/src/tools/: apinames.c test_afm.c test_bbox.c test_trig.c
  group source/component/3rd-party/freetype/raw/src/tools/ftrandom
    ../../../../source/component/3rd-party/freetype/raw/src/tools/ftrandom/: ftrandom.c
  group source/component/3rd-party/freetype/raw/src/truetype
    ../../../../source/component/3rd-party/freetype/raw/src/truetype/: truetype.c ttdriver.c ttdriver.h tterrors.h ttgload.c ttgload.h ttgxvar.c ttgxvar.h ttinterp.c ttinterp.h ttobjs.c ttobjs.h ttpload.c ttpload.h ttsubpix.c ttsubpix.h
  group source/component/3rd-party/freetype/raw/src/type1
    ../../../../source/component/3rd-party/freetype/raw/src/type1/: t1afm.c t1afm.h t1driver.c t1driver.h t1errors.h t1gload.c t1gload.h t1load.c t1load.h t1objs.c t1objs.h t1parse.c t1parse.h t1tokens.h type1.c
  group source/component/3rd-party/freetype/raw/src/type42
    ../../../../source/component/3rd-party/freetype/raw/src/type42/: t42drivr.c t42drivr.h t42error.h t42objs.c t42objs.h t42parse.c t42parse.h t42types.h type42.c
  group source/component/3rd-party/freetype/raw/src/winfonts
    ../../../../source/component/3rd-party/freetype/raw/src/winfonts/: fnterrs.h winfnt.c winfnt.h
  group source/component/3rd-party/gato/raw/examples/graph
    ../../../../source/component/3rd-party/gato/raw/examples/graph/: dock.c example_1.c example_2.c example_3.c example_4.c example_5.c main.h ui.c
  group source/component/3rd-party/gato/raw/image
    ../../../../source/component/3rd-party/gato/raw/image/: image.c stb_image.h stb_image_resize.h stb_image_write.h
  group source/component/3rd-party/gato/raw/include
    ../../../../source/component/3rd-party/gato/raw/include/: color.h consolas-font.h image.h macro.h point.h render.h surface.h svg.h
  group source/component/3rd-party/gato/raw/render
    ../../../../source/component/3rd-party/gato/raw/render/: render.c shape.c surface.c svg.c text.c
  group source/component/3rd-party/gato/raw/scripts
    ../../../../source/component/3rd-party/gato/raw/scripts/: fixdep.c
  group source/component/3rd-party/libjpeg-turbo/port
    ../../../../source/component/3rd-party/libjpeg-turbo/port/: jconfig.h jconfigint.h
  group source/component/3rd-party/libjpeg-turbo/raw
    ../../../../source/component/3rd-party/libjpeg-turbo/raw/: cderror.h cdjpeg.c cdjpeg.h cjpeg.c cmyk.h djpeg.c jaricom.c jcapimin.c jcapistd.c jcarith.c jccoefct.c jccolext.c jccolor.c jcdctmgr.c jchuff.c jchuff.h jcicc.c jcinit.c jcmainct.c jcmarker.c jcmaster.c jcomapi.c jcparam.c jcphuff.c jcprepct.c jcsample.c jcstest.c jctrans.c jdapimin.c jdapistd.c jdarith.c jdatadst-tj.c jdatadst.c jdatasrc-tj.c jdatasrc.c jdcoefct.c jdcoefct.h jdcol565.c jdcolext.c jdcolor.c jdct.h jddctmgr.c jdhuff.c jdhuff.h jdicc.c jdinput.c jdmainct.c jdmainct.h jdmarker.c jdmaster.c jdmaster.h jdmerge.c jdmerge.h jdmrg565.c jdmrgext.c jdphuff.c jdpostct.c jdsample.c jdsample.h jdtrans.c jerror.c jerror.h jfdctflt.c jfdctfst.c jfdctint.c jidctflt.c jidctfst.c jidctint.c jidctred.c jinclude.h jmemmgr.c jmemnobs.c jmemsys.h jmorecfg.h jpeg_nbits_table.h jpegcomp.h jpegint.h jpeglib.h jpegtran.c jquant1.c jquant2.c jsimd.h jsimd_none.c jsimddct.h jstdhuff.c jutils.c jversion.h rdbmp.c rdcolmap.c rdgif.c rdjpgcom.c rdppm.c rdswitch.c rdtarga.c tjbench.c tjexample.c tjunittest.c tjutil.c tjutil.h transupp.c transupp.h turbojpeg-jni.c turbojpeg.c turbojpeg.h wrbmp.c wrgif.c wrjpgcom.c wrppm.c wrtarga.c
  group source/component/3rd-party/libpng/port
    ../../../../source/component/3rd-party/libpng/port/: pnglibconf.h
  group source/component/3rd-party/libpng/raw
    ../../../../source/component/3rd-party/libpng/raw/: example.c png.c png.h pngconf.h pngdebug.h pngerror.c pngget.c pnginfo.h pngmem.c pngpread.c pngpriv.h pngread.c pngrio.c pngrtran.c pngrutil.c pngset.c pngstruct.h pngtest.c pngtrans.c pngwio.c pngwrite.c pngwtran.c pngwutil.c
  group source/component/3rd-party/libpng/raw/arm
    ../../../../source/component/3rd-party/libpng/raw/arm/: arm_init.c filter_neon_intrinsics.c palette_neon_intrinsics.c
  group source/component/3rd-party/libpng/raw/contrib/arm-neon
    ../../../../source/component/3rd-party/libpng/raw/contrib/arm-neon/: android-ndk.c linux-auxv.c linux.c
  group source/component/3rd-party/libpng/raw/contrib/examples
    ../../../../source/component/3rd-party/libpng/raw/contrib/examples/: iccfrompng.c pngpixel.c pngtopng.c simpleover.c
  group source/component/3rd-party/libpng/raw/contrib/gregbook
    ../../../../source/component/3rd-party/libpng/raw/contrib/gregbook/: readpng.c readpng.h readpng2.c readpng2.h readppm.c rpng-win.c rpng-x.c rpng2-win.c rpng2-x.c wpng.c writepng.c writepng.h
  group source/component/3rd-party/libpng/raw/contrib/libtests
    ../../../../source/component/3rd-party/libpng/raw/contrib/libtests/: fakepng.c makepng.c pngimage.c pngstest-errors.h pngstest.c pngunknown.c pngvalid.c readpng.c tarith.c timepng.c
  group source/component/3rd-party/libpng/raw/contrib/mips-msa
    ../../../../source/component/3rd-party/libpng/raw/contrib/mips-msa/: linux.c
  group source/component/3rd-party/libpng/raw/contrib/pngminim/decoder
    ../../../../source/component/3rd-party/libpng/raw/contrib/pngminim/decoder/: pngusr.h
  group source/component/3rd-party/libpng/raw/contrib/pngminim/encoder
    ../../../../source/component/3rd-party/libpng/raw/contrib/pngminim/encoder/: pngusr.h
  group source/component/3rd-party/libpng/raw/contrib/pngminim/preader
    ../../../../source/component/3rd-party/libpng/raw/contrib/pngminim/preader/: pngusr.h
  group source/component/3rd-party/libpng/raw/contrib/pngminus
    ../../../../source/component/3rd-party/libpng/raw/contrib/pngminus/: png2pnm.c pnm2png.c
  group source/component/3rd-party/libpng/raw/contrib/powerpc-vsx
    ../../../../source/component/3rd-party/libpng/raw/contrib/powerpc-vsx/: linux.c linux_aux.c
  group source/component/3rd-party/libpng/raw/contrib/tools
    ../../../../source/component/3rd-party/libpng/raw/contrib/tools/: checksum-icc.c cvtcolor.c genpng.c makesRGB.c png-fix-itxt.c pngcp.c pngfix.c sRGB.h
  group source/component/3rd-party/libpng/raw/contrib/visupng
    ../../../../source/component/3rd-party/libpng/raw/contrib/visupng/: PngFile.c PngFile.h VisualPng.c cexcept.h resource.h
  group source/component/3rd-party/libpng/raw/intel
    ../../../../source/component/3rd-party/libpng/raw/intel/: filter_sse2_intrinsics.c intel_init.c
  group source/component/3rd-party/libpng/raw/mips
    ../../../../source/component/3rd-party/libpng/raw/mips/: filter_msa_intrinsics.c mips_init.c
  group source/component/3rd-party/libpng/raw/powerpc
    ../../../../source/component/3rd-party/libpng/raw/powerpc/: filter_vsx_intrinsics.c powerpc_init.c
  group source/component/3rd-party/libpng/raw/scripts
    ../../../../source/component/3rd-party/libpng/raw/scripts/: intprefix.c prefix.c sym.c symbols.c vers.c
  group source/component/3rd-party/lua/extension/lovevsf
    ../../../../source/component/3rd-party/lua/extension/lovevsf/: lovevsf.c lovevsf.h
  group source/component/3rd-party/lua/extension/lovevsf/modules
    ../../../../source/component/3rd-party/lua/extension/lovevsf/modules/: l_filesystem.c l_font.c l_graphics.c l_image.c l_timer.c
  group source/component/3rd-party/lua/extension/oo
    ../../../../source/component/3rd-party/lua/extension/oo/: lua_oo.c lua_oo.h
  group source/component/3rd-party/lua/port
    ../../../../source/component/3rd-party/lua/port/: lua_port.c
  group source/component/3rd-party/lua/raw
    ../../../../source/component/3rd-party/lua/raw/: lapi.c lapi.h lauxlib.c lauxlib.h lbaselib.c lcode.c lcode.h lcorolib.c lctype.c lctype.h ldblib.c ldebug.c ldebug.h ldo.c ldo.h ldump.c lfunc.c lfunc.h lgc.c lgc.h linit.c liolib.c ljumptab.h llex.c llex.h llimits.h lmathlib.c lmem.c lmem.h loadlib.c lobject.c lobject.h lopcodes.c lopcodes.h lopnames.h loslib.c lparser.c lparser.h lprefix.h lstate.c lstate.h lstring.c lstring.h lstrlib.c ltable.c ltable.h ltablib.c ltests.c ltests.h ltm.c ltm.h lua.c lua.h luaconf.h lualib.h lundump.c lundump.h lutf8lib.c lvm.c lvm.h lzio.c lzio.h onelua.c
  group source/component/3rd-party/lua/raw/testes/libs
    ../../../../source/component/3rd-party/lua/raw/testes/libs/: lib1.c lib11.c lib2.c lib21.c lib22.c
  group source/component/3rd-party/lvgl/extension/lv_lib_freetype/raw
    ../../../../source/component/3rd-party/lvgl/extension/lv_lib_freetype/raw/: lv_freetype.c lv_freetype.h
  group source/component/3rd-party/lvgl/port
    ../../../../source/component/3rd-party/lvgl/port/: vsf_lvgl_port.c vsf_lvgl_port.h
  group source/component/3rd-party/lvgl/raw/lvgl
    ../../../../source/component/3rd-party/lvgl/raw/lvgl/: lv_conf_template.h lvgl.h
  group source/component/3rd-party/lvgl/raw/lvgl/examples/porting
    ../../../../source/component/3rd-party/lvgl/raw/lvgl/examples/porting/: lv_port_disp_template.c lv_port_disp_template.h lv_port_fs_template.c lv_port_fs_template.h lv_port_indev_template.c lv_port_indev_template.h
  group source/component/3rd-party/lvgl/raw/lvgl/src
    ../../../../source/component/3rd-party/lvgl/raw/lvgl/src/: lv_api_map.h lv_conf_internal.h lv_conf_kconfig.h lvgl.h
  group source/component/3rd-party/lvgl/raw/lvgl/src/lv_core
    ../../../../source/component/3rd-party/lvgl/raw/lvgl/src/lv_core/: lv_disp.c lv_disp.h lv_group.c lv_group.h lv_indev.c lv_indev.h lv_obj.c lv_obj.h lv_obj_style_dec.h lv_refr.c lv_refr.h lv_style.c lv_style.h
  group source/component/3rd-party/lvgl/raw/lvgl/src/lv_draw
    ../../../../source/component/3rd-party/lvgl/raw/lvgl/src/lv_draw/: lv_draw.h lv_draw_arc.c lv_draw_arc.h lv_draw_blend.c lv_draw_blend.h lv_draw_img.c lv_draw_img.h lv_draw_label.c lv_draw_label.h lv_draw_line.c lv_draw_line.h lv_draw_mask.c lv_draw_mask.h lv_draw_rect.c lv_draw_rect.h lv_draw_triangle.c lv_draw_triangle.h lv_img_buf.c lv_img_buf.h lv_img_cache.c lv_img_cache.h lv_img_decoder.c lv_img_decoder.h
  group source/component/3rd-party/lvgl/raw/lvgl/src/lv_font
    ../../../../source/component/3rd-party/lvgl/raw/lvgl/src/lv_font/: lv_font.c lv_font.h lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_fmt_txt.h lv_font_loader.c lv_font_loader.h lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_simsun_16_cjk.c lv_font_unscii_16.c lv_font_unscii_8.c lv_symbol_def.h
  group source/component/3rd-party/lvgl/raw/lvgl/src/lv_gpu
    ../../../../source/component/3rd-party/lvgl/raw/lvgl/src/lv_gpu/: lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp.h lv_gpu_nxp_pxp_osa.c lv_gpu_nxp_pxp_osa.h lv_gpu_nxp_vglite.c lv_gpu_nxp_vglite.h lv_gpu_stm32_dma2d.c lv_gpu_stm32_dma2d.h
  group source/component/3rd-party/lvgl/raw/lvgl/src/lv_hal
    ../../../../source/component/3rd-party/lvgl/raw/lvgl/src/lv_hal/: lv_hal.h lv_hal_disp.c lv_hal_disp.h lv_hal_indev.c lv_hal_indev.h lv_hal_tick.c lv_hal_tick.h
  group source/component/3rd-party/lvgl/raw/lvgl/src/lv_misc
    ../../../../source/component/3rd-party/lvgl/raw/lvgl/src/lv_misc/: lv_anim.c lv_anim.h lv_area.c lv_area.h lv_async.c lv_async.h lv_bidi.c lv_bidi.h lv_color.c lv_color.h lv_debug.c lv_debug.h lv_fs.c lv_fs.h lv_gc.c lv_gc.h lv_ll.c lv_ll.h lv_log.c lv_log.h lv_math.c lv_math.h lv_mem.c lv_mem.h lv_printf.c lv_printf.h lv_task.c lv_task.h lv_templ.c lv_templ.h lv_txt.c lv_txt.h lv_txt_ap.c lv_txt_ap.h lv_types.h lv_utils.c lv_utils.h
  group source/component/3rd-party/lvgl/raw/lvgl/src/lv_themes
    ../../../../source/component/3rd-party/lvgl/raw/lvgl/src/lv_themes/: lv_theme.c lv_theme.h lv_theme_empty.c lv_theme_empty.h lv_theme_material.c lv_theme_material.h lv_theme_mono.c lv_theme_mono.h lv_theme_template.c lv_theme_template.h
  group source/component/3rd-party/lvgl/raw/lvgl/src/lv_widgets
    ../../../../source/component/3rd-party/lvgl/raw/lvgl/src/lv_widgets/: lv_arc.c lv_arc.h lv_bar.c lv_bar.h lv_btn.c lv_btn.h lv_btnmatrix.c lv_btnmatrix.h lv_calendar.c lv_calendar.h lv_canvas.c lv_canvas.h lv_chart.c lv_chart.h lv_checkbox.c lv_checkbox.h lv_cont.c lv_cont.h lv_cpicker.c lv_cpicker.h lv_dropdown.c lv_dropdown.h lv_gauge.c lv_gauge.h lv_img.c lv_img.h lv_imgbtn.c lv_imgbtn.h lv_keyboard.c lv_keyboard.h lv_label.c lv_label.h lv_led.c lv_led.h lv_line.c lv_line.h lv_linemeter.c lv_linemeter.h lv_list.c lv_list.h lv_msgbox.c lv_msgbox.h lv_objmask.c lv_objmask.h lv_objx_templ.c lv_objx_templ.h lv_page.c lv_page.h lv_roller.c lv_roller.h lv_slider.c lv_slider.h lv_spinbox.c lv_spinbox.h lv_spinner.c lv_spinner.h lv_switch.c lv_switch.h lv_table.c lv_table.h lv_tabview.c lv_tabview.h lv_textarea.c lv_textarea.h lv_tileview.c lv_tileview.h lv_win.c lv_win.h
  group source/component/3rd-party/lvgl/raw/lvgl/tests
    ../../../../source/component/3rd-party/lvgl/raw/lvgl/tests/: lv_test_assert.c lv_test_assert.h lv_test_conf.h lv_test_main.c
  group source/component/3rd-party/lvgl/raw/lvgl/tests/lv_test_core
    ../../../../source/component/3rd-party/lvgl/raw/lvgl/tests/lv_test_core/: lv_test_core.c lv_test_core.h lv_test_font_loader.c lv_test_font_loader.h lv_test_obj.c lv_test_obj.h lv_test_style.c lv_test_style.h
  group source/component/3rd-party/lvgl/raw/lvgl/tests/lv_test_fonts
    ../../../../source/component/3rd-party/lvgl/raw/lvgl/tests/lv_test_fonts/: font_1.c font_2.c font_3.c
  group source/component/3rd-party/lvgl/raw/lvgl/tests/lv_test_widgets
    ../../../../source/component/3rd-party/lvgl/raw/lvgl/tests/lv_test_widgets/: lv_test_label.c lv_test_label.h
  group source/component/3rd-party/mbedtls/raw/3rdparty/everest/include/everest
    ../../../../source/component/3rd-party/mbedtls/raw/3rdparty/everest/include/everest/: Hacl_Curve25519.h everest.h kremlib.h x25519.h
  group source/component/3rd-party/mbedtls/raw/3rdparty/everest/include/everest/kremlib
    ../../../../source/component/3rd-party/mbedtls/raw/3rdparty/everest/include/everest/kremlib/: FStar_UInt128.h FStar_UInt64_FStar_UInt32_FStar_UInt16_FStar_UInt8.h
  group source/component/3rd-party/mbedtls/raw/3rdparty/everest/include/everest/kremlin
    ../../../../source/component/3rd-party/mbedtls/raw/3rdparty/everest/include/everest/kremlin/: c_endianness.h
  group source/component/3rd-party/mbedtls/raw/3rdparty/everest/include/everest/kremlin/internal
    ../../../../source/component/3rd-party/mbedtls/raw/3rdparty/everest/include/everest/kremlin/internal/: builtin.h callconv.h compat.h debug.h target.h types.h wasmsupport.h
  group source/component/3rd-party/mbedtls/raw/3rdparty/everest/include/everest/vs2010
    ../../../../source/component/3rd-party/mbedtls/raw/3rdparty/everest/include/everest/vs2010/: Hacl_Curve25519.h inttypes.h stdbool.h
  group source/component/3rd-party/mbedtls/raw/3rdparty/everest/library
    ../../../../source/component/3rd-party/mbedtls/raw/3rdparty/everest/library/: Hacl_Curve25519.c Hacl_Curve25519_joined.c everest.c x25519.c
  group source/component/3rd-party/mbedtls/raw/3rdparty/everest/library/kremlib
    ../../../../source/component/3rd-party/mbedtls/raw/3rdparty/everest/library/kremlib/: FStar_UInt128_extracted.c FStar_UInt64_FStar_UInt32_FStar_UInt16_FStar_UInt8.c
  group source/component/3rd-party/mbedtls/raw/3rdparty/everest/library/legacy
    ../../../../source/component/3rd-party/mbedtls/raw/3rdparty/everest/library/legacy/: Hacl_Curve25519.c
  group source/component/3rd-party/mbedtls/raw/configs
    ../../../../source/component/3rd-party/mbedtls/raw/configs/: config-ccm-psk-tls1_2.h config-mini-tls1_1.h config-no-entropy.h config-psa-crypto.h config-suite-b.h config-symmetric-only.h config-thread.h
  group source/component/3rd-party/mbedtls/raw/doxygen/input
    ../../../../source/component/3rd-party/mbedtls/raw/doxygen/input/: doc_encdec.h doc_hashing.h doc_mainpage.h doc_rng.h doc_ssltls.h doc_tcpip.h doc_x509.h
  group source/component/3rd-party/mbedtls/raw/include/mbedtls
    ../../../../source/component/3rd-party/mbedtls/raw/include/mbedtls/: aes.h aesni.h arc4.h aria.h asn1.h asn1write.h base64.h bignum.h blowfish.h bn_mul.h camellia.h ccm.h certs.h chacha20.h chachapoly.h check_config.h cipher.h cipher_internal.h cmac.h compat-1.3.h config.h config_psa.h ctr_drbg.h debug.h des.h dhm.h ecdh.h ecdsa.h ecjpake.h ecp.h ecp_internal.h entropy.h entropy_poll.h error.h gcm.h havege.h hkdf.h hmac_drbg.h md.h md2.h md4.h md5.h md_internal.h memory_buffer_alloc.h net.h net_sockets.h nist_kw.h oid.h padlock.h pem.h pk.h pk_internal.h pkcs11.h pkcs12.h pkcs5.h platform.h platform_time.h platform_util.h poly1305.h psa_util.h ripemd160.h rsa.h rsa_internal.h sha1.h sha256.h sha512.h ssl.h ssl_cache.h ssl_ciphersuites.h ssl_cookie.h ssl_internal.h ssl_ticket.h threading.h timing.h version.h x509.h x509_crl.h x509_crt.h x509_csr.h xtea.h
  group source/component/3rd-party/mbedtls/raw/include/psa
    ../../../../source/component/3rd-party/mbedtls/raw/include/psa/: crypto.h crypto_compat.h crypto_config.h crypto_driver_common.h crypto_extra.h crypto_platform.h crypto_se_driver.h crypto_sizes.h crypto_struct.h crypto_types.h crypto_values.h
  group source/component/3rd-party/mbedtls/raw/library
    ../../../../source/component/3rd-party/mbedtls/raw/library/: aes.c aesni.c arc4.c aria.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c chacha20.c chachapoly.c check_crypto_config.h cipher.c cipher_wrap.c cmac.c common.h ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hkdf.c hmac_drbg.c md.c md2.c md4.c md5.c memory_buffer_alloc.c net_sockets.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs11.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c psa_crypto.c psa_crypto_client.c psa_crypto_core.h psa_crypto_driver_wrappers.c psa_crypto_driver_wrappers.h psa_crypto_ecp.c psa_crypto_ecp.h psa_crypto_invasive.h psa_crypto_its.h psa_crypto_random_impl.h psa_crypto_rsa.c psa_crypto_rsa.h psa_crypto_se.c psa_crypto_se.h psa_crypto_service_integration.h psa_crypto_slot_management.c psa_crypto_slot_management.h psa_crypto_storage.c psa_crypto_storage.h psa_its_file.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_invasive.h ssl_msg.c ssl_srv.c ssl_ticket.c ssl_tls.c ssl_tls13_keys.c ssl_tls13_keys.h threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group source/component/3rd-party/mbedtls/raw/programs
    ../../../../source/component/3rd-party/mbedtls/raw/programs/: wince_main.c
  group source/component/3rd-party/mbedtls/raw/programs/aes
    ../../../../source/component/3rd-party/mbedtls/raw/programs/aes/: aescrypt2.c crypt_and_hash.c
  group source/component/3rd-party/mbedtls/raw/programs/fuzz
    ../../../../source/component/3rd-party/mbedtls/raw/programs/fuzz/: common.c common.h fuzz_client.c fuzz_dtlsclient.c fuzz_dtlsserver.c fuzz_privkey.c fuzz_pubkey.c fuzz_server.c fuzz_x509crl.c fuzz_x509crt.c fuzz_x509csr.c onefile.c
  group source/component/3rd-party/mbedtls/raw/programs/hash
    ../../../../source/component/3rd-party/mbedtls/raw/programs/hash/: generic_sum.c hello.c
  group source/component/3rd-party/mbedtls/raw/programs/pkey
    ../../../../source/component/3rd-party/mbedtls/raw/programs/pkey/: dh_client.c dh_genprime.c dh_server.c ecdh_curve25519.c ecdsa.c gen_key.c key_app.c key_app_writer.c mpi_demo.c pk_decrypt.c pk_encrypt.c pk_sign.c pk_verify.c rsa_decrypt.c rsa_encrypt.c rsa_genkey.c rsa_sign.c rsa_sign_pss.c rsa_verify.c rsa_verify_pss.c
  group source/component/3rd-party/mbedtls/raw/programs/psa
    ../../../../source/component/3rd-party/mbedtls/raw/programs/psa/: crypto_examples.c key_ladder_demo.c psa_constant_names.c psa_constant_names_generated.c
  group source/component/3rd-party/mbedtls/raw/programs/random
    ../../../../source/component/3rd-party/mbedtls/raw/programs/random/: gen_entropy.c gen_random_ctr_drbg.c gen_random_havege.c
  group source/component/3rd-party/mbedtls/raw/programs/ssl
    ../../../../source/component/3rd-party/mbedtls/raw/programs/ssl/: dtls_client.c dtls_server.c mini_client.c ssl_client1.c ssl_client2.c ssl_context_info.c ssl_fork_server.c ssl_mail_client.c ssl_pthread_server.c ssl_server.c ssl_server2.c ssl_test_common_source.c ssl_test_lib.c ssl_test_lib.h
  group source/component/3rd-party/mbedtls/raw/programs/test
    ../../../../source/component/3rd-party/mbedtls/raw/programs/test/: benchmark.c cpp_dummy_build.cpp query_compile_time_config.c query_config.c query_config.h selftest.c udp_proxy.c zeroize.c
  group source/component/3rd-party/mbedtls/raw/programs/util
    ../../../../source/component/3rd-party/mbedtls/raw/programs/util/: pem2der.c strerror.c
  group source/component/3rd-party/mbedtls/raw/programs/x509
    ../../../../source/component/3rd-party/mbedtls/raw/programs/x509/: cert_app.c cert_req.c cert_write.c crl_app.c req_app.c
  group source/component/3rd-party/mbedtls/raw/tests/configs
    ../../../../source/component/3rd-party/mbedtls/raw/tests/configs/: config-wrapper-malloc-0-null.h
  group source/component/3rd-party/mbedtls/raw/tests/include/test
    ../../../../source/component/3rd-party/mbedtls/raw/tests/include/test/: asn1_helpers.h constant_flow.h fake_external_rng_for_test.h helpers.h macros.h psa_crypto_helpers.h psa_exercise_key.h psa_helpers.h random.h
  group source/component/3rd-party/mbedtls/raw/tests/include/test/drivers
    ../../../../source/component/3rd-party/mbedtls/raw/tests/include/test/drivers/: cipher.h key_management.h signature.h size.h test_driver.h
  group source/component/3rd-party/mbedtls/raw/tests/src
    ../../../../source/component/3rd-party/mbedtls/raw/tests/src/: asn1_helpers.c fake_external_rng_for_test.c helpers.c psa_crypto_helpers.c psa_exercise_key.c random.c threading_helpers.c
  group source/component/3rd-party/mbedtls/raw/tests/src/drivers
    ../../../../source/component/3rd-party/mbedtls/raw/tests/src/drivers/: cipher.c key_management.c signature.c size.c
  group source/component/3rd-party/nnom/port
    ../../../../source/component/3rd-party/nnom/port/: nnom_port.h
  group source/component/3rd-party/nnom/raw/examples/auto_test
    ../../../../source/component/3rd-party/nnom/raw/examples/auto_test/: main.c
  group source/component/3rd-party/nnom/raw/examples/keyword_spotting
    ../../../../source/component/3rd-party/nnom/raw/examples/keyword_spotting/: weights.h
  group source/component/3rd-party/nnom/raw/examples/keyword_spotting/mcu
    ../../../../source/component/3rd-party/nnom/raw/examples/keyword_spotting/mcu/: main.c mfcc.c mfcc.h weights.h
  group source/component/3rd-party/nnom/raw/examples/mnist-cnn/mcu
    ../../../../source/component/3rd-party/nnom/raw/examples/mnist-cnn/mcu/: main_cnn.c weights_cnn.h
  group source/component/3rd-party/nnom/raw/examples/mnist-densenet
    ../../../../source/component/3rd-party/nnom/raw/examples/mnist-densenet/: main.c weights.h
  group source/component/3rd-party/nnom/raw/examples/mnist-simple
    ../../../../source/component/3rd-party/nnom/raw/examples/mnist-simple/: image.h weights.h
  group source/component/3rd-party/nnom/raw/examples/mnist-simple/mcu
    ../../../../source/component/3rd-party/nnom/raw/examples/mnist-simple/mcu/: image.h main.c weights.h
  group source/component/3rd-party/nnom/raw/examples/octave-conv
    ../../../../source/component/3rd-party/nnom/raw/examples/octave-conv/: image.h main.c weights.h
  group source/component/3rd-party/nnom/raw/examples/rnn-denoise
    ../../../../source/component/3rd-party/nnom/raw/examples/rnn-denoise/: equalizer_coeff.h main.c main_arm.c mfcc.c mfcc.h wav.h weights.h
  group source/component/3rd-party/nnom/raw/examples/uci-har-rnn
    ../../../../source/component/3rd-party/nnom/raw/examples/uci-har-rnn/: main.c weights.h
  group source/component/3rd-party/nnom/raw/examples/uci-inception
    ../../../../source/component/3rd-party/nnom/raw/examples/uci-inception/: main.c weights.h
  group source/component/3rd-party/nnom/raw/inc
    ../../../../source/component/3rd-party/nnom/raw/inc/: nnom.h nnom_layers.h nnom_local.h nnom_tensor.h nnom_utils.h
  group source/component/3rd-party/nnom/raw/inc/layers
    ../../../../source/component/3rd-party/nnom/raw/inc/layers/: nnom_activation.h nnom_avgpool.h nnom_baselayer.h nnom_concat.h nnom_conv2d.h nnom_conv2d_trans.h nnom_cropping.h nnom_dense.h nnom_dw_conv2d.h nnom_flatten.h nnom_global_pool.h nnom_gru_cell.h nnom_input.h nnom_lambda.h nnom_lstm_cell.h nnom_matrix.h nnom_maxpool.h nnom_output.h nnom_rnn.h nnom_simple_cell.h nnom_softmax.h nnom_sumpool.h nnom_upsample.h nnom_zero_padding.h
  group source/component/3rd-party/nnom/raw/port
    ../../../../source/component/3rd-party/nnom/raw/port/: nnom_port.h
  group source/component/3rd-party/nnom/raw/src/backends
    ../../../../source/component/3rd-party/nnom/raw/src/backends/: nnom_local.c nnom_local_q15.c
  group source/component/3rd-party/nnom/raw/src/core
    ../../../../source/component/3rd-party/nnom/raw/src/core/: nnom.c nnom_layers.c nnom_tensor.c nnom_utils.c
  group source/component/3rd-party/nnom/raw/src/layers
    ../../../../source/component/3rd-party/nnom/raw/src/layers/: nnom_activation.c nnom_avgpool.c nnom_baselayer.c nnom_concat.c nnom_conv2d.c nnom_conv2d_trans.c nnom_cropping.c nnom_dense.c nnom_dw_conv2d.c nnom_flatten.c nnom_global_pool.c nnom_gru_cell.c nnom_input.c nnom_lambda.c nnom_lstm_cell.c nnom_matrix.c nnom_maxpool.c nnom_output.c nnom_rnn.c nnom_simple_cell.c nnom_softmax.c nnom_sumpool.c nnom_upsample.c nnom_zero_padding.c
  group source/component/3rd-party/nuconsole/raw
    ../../../../source/component/3rd-party/nuconsole/raw/: NuConsole.c NuConsole.h NuConsole_Config.h
  group source/component/3rd-party/nuklear/raw
    ../../../../source/component/3rd-party/nuklear/raw/: nuklear.h
  group source/component/3rd-party/nuklear/raw/demo
    ../../../../source/component/3rd-party/nuklear/raw/demo/: calculator.c node_editor.c overview.c style.c
  group source/component/3rd-party/nuklear/raw/demo/allegro5
    ../../../../source/component/3rd-party/nuklear/raw/demo/allegro5/: KeyboardHandleriOS.h main.c nuklear_allegro5.h
  group source/component/3rd-party/nuklear/raw/demo/d3d11
    ../../../../source/component/3rd-party/nuklear/raw/demo/d3d11/: main.c nuklear_d3d11.h nuklear_d3d11_pixel_shader.h nuklear_d3d11_vertex_shader.h
  group source/component/3rd-party/nuklear/raw/demo/d3d9
    ../../../../source/component/3rd-party/nuklear/raw/demo/d3d9/: main.c nuklear_d3d9.h
  group source/component/3rd-party/nuklear/raw/demo/gdi
    ../../../../source/component/3rd-party/nuklear/raw/demo/gdi/: main.c nuklear_gdi.h
  group source/component/3rd-party/nuklear/raw/demo/gdip
    ../../../../source/component/3rd-party/nuklear/raw/demo/gdip/: main.c nuklear_gdip.h
  group source/component/3rd-party/nuklear/raw/demo/glfw_opengl2
    ../../../../source/component/3rd-party/nuklear/raw/demo/glfw_opengl2/: main.c nuklear_glfw_gl2.h
  group source/component/3rd-party/nuklear/raw/demo/glfw_opengl3
    ../../../../source/component/3rd-party/nuklear/raw/demo/glfw_opengl3/: main.c nuklear_glfw_gl3.h
  group source/component/3rd-party/nuklear/raw/demo/glfw_opengl4
    ../../../../source/component/3rd-party/nuklear/raw/demo/glfw_opengl4/: main.c nuklear_glfw_gl4.h
  group source/component/3rd-party/nuklear/raw/demo/sdl2surface_rawfb
    ../../../../source/component/3rd-party/nuklear/raw/demo/sdl2surface_rawfb/: main.c sdl2surface_rawfb.h
  group source/component/3rd-party/nuklear/raw/demo/sdl_opengl2
    ../../../../source/component/3rd-party/nuklear/raw/demo/sdl_opengl2/: main.c nuklear_sdl_gl2.h
  group source/component/3rd-party/nuklear/raw/demo/sdl_opengl3
    ../../../../source/component/3rd-party/nuklear/raw/demo/sdl_opengl3/: main.c nuklear_sdl_gl3.h
  group source/component/3rd-party/nuklear/raw/demo/sdl_opengles2
    ../../../../source/component/3rd-party/nuklear/raw/demo/sdl_opengles2/: main.c nuklear_sdl_gles2.h
  group source/component/3rd-party/nuklear/raw/demo/sfml_opengl2
    ../../../../source/component/3rd-party/nuklear/raw/demo/sfml_opengl2/: main.cpp nuklear_sfml_gl2.h
  group source/component/3rd-party/nuklear/raw/demo/sfml_opengl3
    ../../../../source/component/3rd-party/nuklear/raw/demo/sfml_opengl3/: main.cpp nuklear_sfml_gl3.h
  group source/component/3rd-party/nuklear/raw/demo/wayland_rawfb
    ../../../../source/component/3rd-party/nuklear/raw/demo/wayland_rawfb/: main.c nuklear_raw_wayland.h
  group source/component/3rd-party/nuklear/raw/demo/x11
    ../../../../source/component/3rd-party/nuklear/raw/demo/x11/: main.c nuklear_xlib.h
  group source/component/3rd-party/nuklear/raw/demo/x11_opengl2
    ../../../../source/component/3rd-party/nuklear/raw/demo/x11_opengl2/: main.c nuklear_xlib_gl2.h
  group source/component/3rd-party/nuklear/raw/demo/x11_opengl3
    ../../../../source/component/3rd-party/nuklear/raw/demo/x11_opengl3/: main.c nuklear_xlib_gl3.h
  group source/component/3rd-party/nuklear/raw/demo/x11_rawfb
    ../../../../source/component/3rd-party/nuklear/raw/demo/x11_rawfb/: main.c nuklear_rawfb.h nuklear_xlib.h
  group source/component/3rd-party/nuklear/raw/demo/x11_xft
    ../../../../source/component/3rd-party/nuklear/raw/demo/x11_xft/: main.c nuklear_xlib.h
  group source/component/3rd-party/nuklear/raw/doc
    ../../../../source/component/3rd-party/nuklear/raw/doc/: stddoc.c
  group source/component/3rd-party/nuklear/raw/example
    ../../../../source/component/3rd-party/nuklear/raw/example/: canvas.c extended.c file_browser.c skinning.c stb_image.h
  group source/component/3rd-party/nuklear/raw/src
    ../../../../source/component/3rd-party/nuklear/raw/src/: nuklear.h nuklear_buffer.c nuklear_button.c nuklear_chart.c nuklear_color.c nuklear_color_picker.c nuklear_combo.c nuklear_context.c nuklear_contextual.c nuklear_draw.c nuklear_edit.c nuklear_font.c nuklear_group.c nuklear_image.c nuklear_input.c nuklear_internal.h nuklear_layout.c nuklear_list_view.c nuklear_math.c nuklear_menu.c nuklear_page_element.c nuklear_panel.c nuklear_pool.c nuklear_popup.c nuklear_progress.c nuklear_property.c nuklear_scrollbar.c nuklear_selectable.c nuklear_slider.c nuklear_string.c nuklear_style.c nuklear_table.c nuklear_text.c nuklear_text_editor.c nuklear_toggle.c nuklear_tooltip.c nuklear_tree.c nuklear_utf8.c nuklear_util.c nuklear_vertex.c nuklear_widget.c nuklear_window.c stb_rect_pack.h stb_truetype.h
  group source/component/3rd-party/segger/port
    ../../../../source/component/3rd-party/segger/port/: SEGGER_SYSVIEW_VSF.c SEGGER_SYSVIEW_VSF.h
  group source/component/3rd-party/segger/port/Config
    ../../../../source/component/3rd-party/segger/port/Config/: Global.h SEGGER_RTT_Conf.h SEGGER_SYSVIEW_Conf.h SEGGER_SYSVIEW_Config_VSF.c
  group source/component/3rd-party/segger/raw/RTT
    ../../../../source/component/3rd-party/segger/raw/RTT/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_printf.c
  group source/component/3rd-party/segger/raw/SystemView
    ../../../../source/component/3rd-party/segger/raw/SystemView/: SEGGER.h SEGGER_SYSVIEW.c SEGGER_SYSVIEW.h SEGGER_SYSVIEW_ConfDefaults.h SEGGER_SYSVIEW_Int.h
  group source/component/3rd-party/vsfip/raw
    ../../../../source/component/3rd-party/vsfip/raw/: vsfip.c vsfip.h
  group source/component/3rd-party/vsfip/raw/netif
    ../../../../source/component/3rd-party/vsfip/raw/netif/: vsfip_netdrv_adapter.c vsfip_netdrv_adapter.h vsfip_netif.c vsfip_netif.h
  group source/component/3rd-party/vsfip/raw/netif/eth
    ../../../../source/component/3rd-party/vsfip/raw/netif/eth/: vsfip_eth.c vsfip_eth.h
  group source/component/3rd-party/vsfip/raw/proto/dhcp
    ../../../../source/component/3rd-party/vsfip/raw/proto/dhcp/: vsfip_dhcp_common.c vsfip_dhcp_common.h vsfip_dhcpc.c vsfip_dhcpc.h vsfip_dhcpd.c vsfip_dhcpd.h
  group source/component/3rd-party/vsfip/raw/proto/dns
    ../../../../source/component/3rd-party/vsfip/raw/proto/dns/: vsfip_dnsc.c vsfip_dnsc.h
  group source/component/3rd-party/vsfvm/extension/vsf/kernel
    ../../../../source/component/3rd-party/vsfvm/extension/vsf/kernel/: vsfvm_ext_kernel.c vsfvm_ext_kernel.h
  group source/component/3rd-party/vsfvm/extension/vsf/libusb
    ../../../../source/component/3rd-party/vsfvm/extension/vsf/libusb/: vsfvm_ext_libusb.c vsfvm_ext_libusb.h
  group source/component/3rd-party/vsfvm/raw
    ../../../../source/component/3rd-party/vsfvm/raw/: vsf_vm.h vsf_vm_cfg.h
  group source/component/3rd-party/vsfvm/raw/common
    ../../../../source/component/3rd-party/vsfvm/raw/common/: vsfvm_bytecode.h vsfvm_common.h vsfvm_objdump.c vsfvm_objdump.h
  group source/component/3rd-party/vsfvm/raw/compiler
    ../../../../source/component/3rd-party/vsfvm/raw/compiler/: vsfvm_compiler.c vsfvm_compiler.h vsfvm_snapshot.c vsfvm_snapshot.h
  group source/component/3rd-party/vsfvm/raw/compiler/lexer
    ../../../../source/component/3rd-party/vsfvm/raw/compiler/lexer/: vsfvm_lexer.c vsfvm_lexer.h
  group source/component/3rd-party/vsfvm/raw/compiler/lexer/dart
    ../../../../source/component/3rd-party/vsfvm/raw/compiler/lexer/dart/: vsfvm_lexer_dart.c vsfvm_lexer_dart.h
  group source/component/3rd-party/vsfvm/raw/extension
    ../../../../source/component/3rd-party/vsfvm/raw/extension/: vsfvm_ext.c
  group source/component/3rd-party/vsfvm/raw/extension/std
    ../../../../source/component/3rd-party/vsfvm/raw/extension/std/: vsfvm_ext_std.c vsfvm_ext_std.h
  group source/component/3rd-party/vsfvm/raw/runtime
    ../../../../source/component/3rd-party/vsfvm/raw/runtime/: vsfvm_runtime.c vsfvm_runtime.h
  group source/component/3rd-party/zlib/raw
    ../../../../source/component/3rd-party/zlib/raw/: adler32.c compress.c crc32.c crc32.h deflate.c deflate.h gzclose.c gzguts.h gzlib.c gzread.c gzwrite.c infback.c inffast.c inffast.h inffixed.h inflate.c inflate.h inftrees.c inftrees.h trees.c trees.h uncompr.c zconf.h zlib.h zutil.c zutil.h
  group source/component/3rd-party/zlib/raw/contrib/blast
    ../../../../source/component/3rd-party/zlib/raw/contrib/blast/: blast.c blast.h
  group source/component/3rd-party/zlib/raw/contrib/infback9
    ../../../../source/component/3rd-party/zlib/raw/contrib/infback9/: infback9.c infback9.h inffix9.h inflate9.h inftree9.c inftree9.h
  group source/component/3rd-party/zlib/raw/contrib/inflate86
    ../../../../source/component/3rd-party/zlib/raw/contrib/inflate86/: inffas86.c
  group source/component/3rd-party/zlib/raw/contrib/iostream
    ../../../../source/component/3rd-party/zlib/raw/contrib/iostream/: test.cpp zfstream.cpp zfstream.h
  group source/component/3rd-party/zlib/raw/contrib/iostream2
    ../../../../source/component/3rd-party/zlib/raw/contrib/iostream2/: zstream.h zstream_test.cpp
  group source/component/3rd-party/zlib/raw/contrib/iostream3
    ../../../../source/component/3rd-party/zlib/raw/contrib/iostream3/: zfstream.h
  group source/component/3rd-party/zlib/raw/contrib/masmx64
    ../../../../source/component/3rd-party/zlib/raw/contrib/masmx64/: inffas8664.c
  group source/component/3rd-party/zlib/raw/contrib/minizip
    ../../../../source/component/3rd-party/zlib/raw/contrib/minizip/: crypt.h ioapi.c ioapi.h iowin32.c iowin32.h miniunz.c minizip.c mztools.c mztools.h unzip.c unzip.h zip.c zip.h
  group source/component/3rd-party/zlib/raw/contrib/puff
    ../../../../source/component/3rd-party/zlib/raw/contrib/puff/: puff.c puff.h pufftest.c
  group source/component/3rd-party/zlib/raw/contrib/testzlib
    ../../../../source/component/3rd-party/zlib/raw/contrib/testzlib/: testzlib.c
  group source/component/3rd-party/zlib/raw/contrib/untgz
    ../../../../source/component/3rd-party/zlib/raw/contrib/untgz/: untgz.c
  group source/component/3rd-party/zlib/raw/examples
    ../../../../source/component/3rd-party/zlib/raw/examples/: enough.c fitblk.c gun.c gzappend.c gzjoin.c gzlog.c gzlog.h zpipe.c zran.c
  group source/component/3rd-party/zlib/raw/test
    ../../../../source/component/3rd-party/zlib/raw/test/: example.c infcover.c minigzip.c
  group source/component/av
    ../../../../source/component/av/: vsf_av.h vsf_av_cfg.h
  group source/component/av/audio
    ../../../../source/component/av/audio/: vsf_audio.c vsf_audio.h
  group source/component/av/audio/decoder/wav
    ../../../../source/component/av/audio/decoder/wav/: vsf_wav.c vsf_wav.h
  group source/component/av/audio/driver/winsound
    ../../../../source/component/av/audio/driver/winsound/: vsf_winsound.c vsf_winsound.h
  group source/component/crypto
    ../../../../source/component/crypto/: vsf_crypto.h vsf_crypto_cfg.h
  group source/component/crypto/hash
    ../../../../source/component/crypto/hash/: vsf_hash.h
  group source/component/crypto/hash/crc
    ../../../../source/component/crypto/hash/crc/: vsf_crc.c vsf_crc.h
  group source/component/debugger
    ../../../../source/component/debugger/: vsf_debugger.h vsf_debugger_cfg.h
  group source/component/debugger/nulink
    ../../../../source/component/debugger/nulink/: NuConsole_stream.c NuConsole_stream.h
  group source/component/debugger/segger
    ../../../../source/component/debugger/segger/: segger_rtt_stream.c segger_rtt_stream.h
  group source/component/fs
    ../../../../source/component/fs/: vsf_fs.c vsf_fs.h vsf_fs_cfg.h
  group source/component/fs/driver/fatfs
    ../../../../source/component/fs/driver/fatfs/: vsf_fatfs.c vsf_fatfs.h
  group source/component/fs/driver/malfs
    ../../../../source/component/fs/driver/malfs/: vsf_malfs.c vsf_malfs.h
  group source/component/fs/driver/memfs
    ../../../../source/component/fs/driver/memfs/: vsf_memfs.c vsf_memfs.h
  group source/component/fs/driver/winfs
    ../../../../source/component/fs/driver/winfs/: vsf_winfs.c vsf_winfs.h
  group source/component/input
    ../../../../source/component/input/: vsf_input.c vsf_input.h vsf_input_cfg.h vsf_input_get_type.h vsf_input_get_type_1bit.h vsf_input_get_type_4bit.h
  group source/component/input/driver/hid
    ../../../../source/component/input/driver/hid/: vsf_input_hid.c vsf_input_hid.h
  group source/component/input/driver/nspro
    ../../../../source/component/input/driver/nspro/: vsf_input_nspro.c vsf_input_nspro.h
  group source/component/input/protocol
    ../../../../source/component/input/protocol/: vsf_input_gamepad.c vsf_input_gamepad.h vsf_input_keyboard.c vsf_input_keyboard.h vsf_input_mouse.c vsf_input_mouse.h vsf_input_sensor.c vsf_input_sensor.h vsf_input_touchscreen.c vsf_input_touchscreen.h
  group source/component/mal
    ../../../../source/component/mal/: vsf_mal.c vsf_mal.h vsf_mal_cfg.h
  group source/component/mal/driver/fakefat32_mal
    ../../../../source/component/mal/driver/fakefat32_mal/: vsf_fakefat32_mal.c vsf_fakefat32_mal.h
  group source/component/mal/driver/file_mal
    ../../../../source/component/mal/driver/file_mal/: vsf_file_mal.c vsf_file_mal.h
  group source/component/mal/driver/mem_mal
    ../../../../source/component/mal/driver/mem_mal/: vsf_mem_mal.c vsf_mem_mal.h
  group source/component/mal/driver/mim_mal
    ../../../../source/component/mal/driver/mim_mal/: vsf_mim_mal.c vsf_mim_mal.h
  group source/component/mal/driver/scsi_mal
    ../../../../source/component/mal/driver/scsi_mal/: vsf_scsi_mal.c vsf_scsi_mal.h
  group source/component/scsi
    ../../../../source/component/scsi/: vsf_scsi.c vsf_scsi.h vsf_scsi_cfg.h
  group source/component/scsi/driver/mal_scsi
    ../../../../source/component/scsi/driver/mal_scsi/: vsf_mal_scsi.c vsf_mal_scsi.h
  group source/component/scsi/driver/virtual_scsi
    ../../../../source/component/scsi/driver/virtual_scsi/: vsf_virtual_scsi.c vsf_virtual_scsi.h
  group source/component/tcpip
    ../../../../source/component/tcpip/: vsf_tcpip.h vsf_tcpip_cfg.h
  group source/component/tcpip/netdrv
    ../../../../source/component/tcpip/netdrv/: vsf_netdrv.c vsf_netdrv.h
  group source/component/tcpip/netdrv/driver/wpcap
    ../../../../source/component/tcpip/netdrv/driver/wpcap/: vsf_netdrv_wpcap.c vsf_netdrv_wpcap.h
  group source/component/tcpip/socket
    ../../../../source/component/tcpip/socket/: vsf_socket.c vsf_socket.h
  group source/component/tcpip/socket/driver/lwip
    ../../../../source/component/tcpip/socket/driver/lwip/: vsf_socket_lwip.c vsf_socket_lwip.h
  group source/component/tcpip/socket/driver/win
    ../../../../source/component/tcpip/socket/driver/win/: vsf_socket_win.c vsf_socket_win.h
  group source/component/ui
    ../../../../source/component/ui/: vsf_ui.h vsf_ui_cfg.h
  group source/component/ui/disp
    ../../../../source/component/ui/disp/: vsf_disp.c vsf_disp.h
  group source/component/ui/disp/driver/fb
    ../../../../source/component/ui/disp/driver/fb/: vsf_disp_fb.c vsf_disp_fb.h
  group source/component/ui/disp/driver/mipi_lcd
    ../../../../source/component/ui/disp/driver/mipi_lcd/: vsf_disp_mipi_lcd.c vsf_disp_mipi_lcd.h
  group source/component/ui/disp/driver/sdl2
    ../../../../source/component/ui/disp/driver/sdl2/: vsf_disp_sdl2.c vsf_disp_sdl2.h
  group source/component/ui/disp/driver/sitronix/common
    ../../../../source/component/ui/disp/driver/sitronix/common/: vsf_disp_sitronix_common.c vsf_disp_sitronix_common.h
  group source/component/ui/disp/driver/sitronix/st7735
    ../../../../source/component/ui/disp/driver/sitronix/st7735/: vsf_disp_st7735.c vsf_disp_st7735.h
  group source/component/ui/disp/driver/sitronix/st7789
    ../../../../source/component/ui/disp/driver/sitronix/st7789/: vsf_disp_st7789.c vsf_disp_st7789.h
  group source/component/ui/disp/driver/solomon-systech/common
    ../../../../source/component/ui/disp/driver/solomon-systech/common/: vsf_disp_solomon_systech_common.c vsf_disp_solomon_systech_common.h
  group source/component/ui/disp/driver/solomon-systech/ssd1306
    ../../../../source/component/ui/disp/driver/solomon-systech/ssd1306/: vsf_disp_ssd1306.c vsf_disp_ssd1306.h
  group source/component/ui/disp/driver/usbd_uvc
    ../../../../source/component/ui/disp/driver/usbd_uvc/: vsf_disp_usbd_uvc.c vsf_disp_usbd_uvc.h
  group source/component/ui/disp/driver/vga/m480
    ../../../../source/component/ui/disp/driver/vga/m480/: vsf_disp_vga_m480.c vsf_disp_vga_m480.h
  group source/component/ui/tgui
    ../../../../source/component/ui/tgui/: vsf_tgui.c vsf_tgui.h vsf_tgui_cfg.h vsf_tgui_common.c vsf_tgui_common.h vsf_tgui_input.c
  group source/component/ui/tgui/controls
    ../../../../source/component/ui/tgui/controls/: __vk_tgui_slider.c __vk_tgui_slider.h __vsf_tgui_controls_common.h vsf_msg_tree_cfg.h vsf_tgui_button.c vsf_tgui_button.h vsf_tgui_control.c vsf_tgui_control.h vsf_tgui_controls.h vsf_tgui_controls_common.c vsf_tgui_label.c vsf_tgui_label.h vsf_tgui_list.c vsf_tgui_list.h vsf_tgui_panel.c vsf_tgui_panel.h vsf_tgui_text_list.c vsf_tgui_text_list.h
  group source/component/ui/tgui/utilities
    ../../../../source/component/ui/tgui/utilities/: vsf_tgui_text.c vsf_tgui_text.h
  group source/component/ui/tgui/view
    ../../../../source/component/ui/tgui/view/: vsf_tgui_v.c vsf_tgui_v.h
  group source/component/ui/tgui/view/simple_view
    ../../../../source/component/ui/tgui/view/simple_view/: vsf_tgui_sv_button.c vsf_tgui_sv_button.h vsf_tgui_sv_color.c vsf_tgui_sv_color.h vsf_tgui_sv_container.c vsf_tgui_sv_container.h vsf_tgui_sv_control.c vsf_tgui_sv_control.h vsf_tgui_sv_draw.c vsf_tgui_sv_draw.h vsf_tgui_sv_font.c vsf_tgui_sv_font.h vsf_tgui_sv_label.c vsf_tgui_sv_label.h vsf_tgui_sv_list.c vsf_tgui_sv_list.h vsf_tgui_sv_panel.c vsf_tgui_sv_panel.h vsf_tgui_sv_port.h vsf_tgui_sv_style.c vsf_tgui_sv_style.h vsf_tgui_sv_text_list.c vsf_tgui_sv_text_list.h vsf_tgui_v_template.h vsf_tgui_v_type.h
  group source/component/ui/tgui/view/template
    ../../../../source/component/ui/tgui/view/template/: vsf_tgui_v_button.c vsf_tgui_v_button.h vsf_tgui_v_container.c vsf_tgui_v_container.h vsf_tgui_v_control.c vsf_tgui_v_control.h vsf_tgui_v_label.c vsf_tgui_v_label.h vsf_tgui_v_panel.c vsf_tgui_v_panel.h vsf_tgui_v_template.h vsf_tgui_v_type.h
  group source/component/usb
    ../../../../source/component/usb/: vsf_usb.h vsf_usb_cfg.h
  group source/component/usb/common
    ../../../../source/component/usb/common/: usb_common.h usb_desc.h
  group source/component/usb/common/class/CDC
    ../../../../source/component/usb/common/class/CDC/: vsf_usb_CDC.h vsf_usb_CDCACM.h
  group source/component/usb/common/class/DFU
    ../../../../source/component/usb/common/class/DFU/: vsf_usb_dfu.h
  group source/component/usb/common/class/HID
    ../../../../source/component/usb/common/class/HID/: vsf_usb_HID.h vsf_usb_ds4.h vsf_usb_nspro.h vsf_usb_xb360.h
  group source/component/usb/common/class/HUB
    ../../../../source/component/usb/common/class/HUB/: vsf_usb_HUB.h
  group source/component/usb/common/class/MSC
    ../../../../source/component/usb/common/class/MSC/: vsf_usb_MSC.h
  group source/component/usb/common/class/UAC
    ../../../../source/component/usb/common/class/UAC/: vsf_usb_UAC.h
  group source/component/usb/common/class/UVC
    ../../../../source/component/usb/common/class/UVC/: vsf_usb_UVC.h
  group source/component/usb/common/class/XB1
    ../../../../source/component/usb/common/class/XB1/: vsf_usb_xb1.h
  group source/component/usb/device
    ../../../../source/component/usb/device/: vsf_usbd.c vsf_usbd.h vsf_usbd_drv_ifs.h
  group source/component/usb/device/class/CDC
    ../../../../source/component/usb/device/class/CDC/: vsf_usbd_CDC.c vsf_usbd_CDC.h vsf_usbd_CDCACM.c vsf_usbd_CDCACM.h vsf_usbd_CDCACM_desc.h
  group source/component/usb/device/class/HID
    ../../../../source/component/usb/device/class/HID/: vsf_usbd_HID.c vsf_usbd_HID.h vsf_usbd_HID_desc.h
  group source/component/usb/device/class/MSC
    ../../../../source/component/usb/device/class/MSC/: vsf_usbd_MSC.c vsf_usbd_MSC.h vsf_usbd_MSC_desc.h
  group source/component/usb/device/class/UAC
    ../../../../source/component/usb/device/class/UAC/: vsf_usbd_UAC.c vsf_usbd_UAC.h
  group source/component/usb/device/class/UVC
    ../../../../source/component/usb/device/class/UVC/: vsf_usbd_UVC.c vsf_usbd_UVC.h
  group source/component/usb/device/extension/bos
    ../../../../source/component/usb/device/extension/bos/: vsf_usbd_bos.h
  group source/component/usb/device/extension/webusb
    ../../../../source/component/usb/device/extension/webusb/: vsf_usbd_webusb.h
  group source/component/usb/device/extension/winusb
    ../../../../source/component/usb/device/extension/winusb/: vsf_usbd_winusb.h
  group source/component/usb/driver/dcd/usbip_dcd
    ../../../../source/component/usb/driver/dcd/usbip_dcd/: vsf_usbip_dcd.c vsf_usbip_dcd.h
  group source/component/usb/driver/dcd/usbip_dcd/backend
    ../../../../source/component/usb/driver/dcd/usbip_dcd/backend/: vsf_usbip_dcd_lwip.c vsf_usbip_dcd_win.c
  group source/component/usb/driver/hcd/libusb_hcd
    ../../../../source/component/usb/driver/hcd/libusb_hcd/: vsf_libusb_hcd.c vsf_libusb_hcd.h
  group source/component/usb/driver/hcd/ohci
    ../../../../source/component/usb/driver/hcd/ohci/: vsf_ohci.c vsf_ohci.h
  group source/component/usb/driver/hcd/winusb_hcd
    ../../../../source/component/usb/driver/hcd/winusb_hcd/: vsf_winusb_hcd.c vsf_winusb_hcd.h
  group source/component/usb/driver/otg/dwcotg
    ../../../../source/component/usb/driver/otg/dwcotg/: dwcotg_regs.h vsf_dwcotg_common.c vsf_dwcotg_common.h vsf_dwcotg_dcd.c vsf_dwcotg_dcd.h vsf_dwcotg_hcd.c vsf_dwcotg_hcd.h vsf_dwcotg_hw.h
  group source/component/usb/driver/otg/musb/fdrc
    ../../../../source/component/usb/driver/otg/musb/fdrc/: __vsf_musb_fdrc_common.c __vsf_musb_fdrc_common.h vsf_musb_fdrc_dcd.c vsf_musb_fdrc_dcd.h vsf_musb_fdrc_hcd.c vsf_musb_fdrc_hcd.h
  group source/component/usb/host
    ../../../../source/component/usb/host/: vsf_usbh.c vsf_usbh.h
  group source/component/usb/host/class/BTHCI
    ../../../../source/component/usb/host/class/BTHCI/: vsf_usbh_BTHCI.c vsf_usbh_BTHCI.h
  group source/component/usb/host/class/CDC
    ../../../../source/component/usb/host/class/CDC/: vsf_usbh_CDC.c vsf_usbh_CDC.h vsf_usbh_CDCECM.c vsf_usbh_CDCECM.h
  group source/component/usb/host/class/DFU
    ../../../../source/component/usb/host/class/DFU/: vsf_usbh_dfu.c vsf_usbh_dfu.h
  group source/component/usb/host/class/DL1x5
    ../../../../source/component/usb/host/class/DL1x5/: vsf_usbh_dl1x5.c vsf_usbh_dl1x5.h
  group source/component/usb/host/class/HID
    ../../../../source/component/usb/host/class/HID/: vsf_usbh_HID.c vsf_usbh_HID.h vsf_usbh_ds4.c vsf_usbh_ds4.h vsf_usbh_nspro.c vsf_usbh_nspro.h vsf_usbh_xb360.c vsf_usbh_xb360.h
  group source/component/usb/host/class/HUB
    ../../../../source/component/usb/host/class/HUB/: vsf_usbh_HUB.c vsf_usbh_HUB.h
  group source/component/usb/host/class/MSC
    ../../../../source/component/usb/host/class/MSC/: vsf_usbh_msc.c vsf_usbh_msc.h
  group source/component/usb/host/class/UAC
    ../../../../source/component/usb/host/class/UAC/: vsf_usbh_uac.c vsf_usbh_uac.h
  group source/component/usb/host/class/XB1
    ../../../../source/component/usb/host/class/XB1/: vsf_usbh_xb1.c vsf_usbh_xb1.h
  group source/component/usb/host/class/libusb
    ../../../../source/component/usb/host/class/libusb/: vsf_usbh_libusb.c vsf_usbh_libusb.h
  group source/hal
    ../../../../source/hal/: vsf_hal.c vsf_hal.h vsf_hal_cfg.h
  group source/hal/arch
    ../../../../source/hal/arch/: __vsf_arch_interface.h vsf_arch.h vsf_arch_abstraction.c vsf_arch_abstraction.h
  group source/hal/arch/arm/arm9
    ../../../../source/hal/arch/arm/arm9/: arm9_generic.c arm9_generic.h
  group source/hal/arch/arm/cortex-a
    ../../../../source/hal/arch/arm/cortex-a/: cortex_a_generic.c cortex_a_generic.h
  group source/hal/arch/arm/cortex-m
    ../../../../source/hal/arch/arm/cortex-m/: cortex_m_generic.c cortex_m_generic.h
  group source/hal/arch/arm/cortex-m/SysTick
    ../../../../source/hal/arch/arm/cortex-m/SysTick/: i_io_systick.h systick.c systick.h systick_internal.c systick_internal.h
  group source/hal/arch/common/arch_without_thread_suspend
    ../../../../source/hal/arch/common/arch_without_thread_suspend/: vsf_arch_without_thread_suspend_template.h
  group source/hal/arch/mcs51
    ../../../../source/hal/arch/mcs51/: mcs51_generic.c mcs51_generic.h
  group source/hal/arch/rtos
    ../../../../source/hal/arch/rtos/: rtos_generic.c rtos_generic.h
  group source/hal/arch/rtos/freertos
    ../../../../source/hal/arch/rtos/freertos/: freertos_generic.c freertos_generic.h
  group source/hal/arch/rv
    ../../../../source/hal/arch/rv/: rv_generic.c rv_generic.h
  group source/hal/arch/template
    ../../../../source/hal/arch/template/: template_generic.c template_generic.h
  group source/hal/driver
    ../../../../source/hal/driver/: driver.h
  group source/hal/driver/arm
    ../../../../source/hal/driver/arm/: driver.h
  group source/hal/driver/arm/mps2
    ../../../../source/hal/driver/arm/mps2/: __device.h driver.h
  group source/hal/driver/arm/mps2/CMSDK_CM7
    ../../../../source/hal/driver/arm/mps2/CMSDK_CM7/: device.h driver.h startup_ARMCM7.c driver.c
  group source/hal/driver/arm/mps2/common
    ../../../../source/hal/driver/arm/mps2/common/: __common.c __common.h
  group source/hal/driver/arm/mps2/common/debug_uart
    ../../../../source/hal/driver/arm/mps2/common/debug_uart/: debug_uart.c debug_uart.h
  group source/hal/driver/Hercules
    ../../../../source/hal/driver/hercules/: driver.h
  group source/hal/driver/Hercules/cmem7
    ../../../../source/hal/driver/hercules/cmem7/: __device.h
  group source/hal/driver/Hercules/cmem7/M7M12N5
    ../../../../source/hal/driver/hercules/cmem7/M7M12N5/: device.h driver.h m7_driver.c
  group source/hal/driver/Hercules/cmem7/common/usb
    ../../../../source/hal/driver/hercules/cmem7/common/usb/: usb.c usb.h usb_common.c usb_lv0.c
  group source/hal/driver/Hercules/cmem7/common/usb/dc
    ../../../../source/hal/driver/hercules/cmem7/common/usb/dc/: usbd.c usbd.h
  group source/hal/driver/Hercules/cmem7/common/usb/hc
    ../../../../source/hal/driver/hercules/cmem7/common/usb/hc/: usbh.c usbh.h
  group source/hal/driver/Hercules/cmem7/common/debug_uart
    ../../../../source/hal/driver/hercules/cmem7/common/debug_uart/: debug_uart.h m7_debug_uart.c
  group source/hal/driver/Hercules/cmem7/common/vendor/Driver/src
    ../../../../source/hal/driver/hercules/cmem7/common/Vendor/Driver/src/: cmem7_adc.c cmem7_aes.c cmem7_can.c cmem7_ddr.c cmem7_ddr_tuning.c cmem7_dma.c cmem7_efuse.c cmem7_eth.c cmem7_flash.c cmem7_gpio.c cmem7_i2c.c cmem7_misc.c cmem7_rtc.c cmem7_spi.c cmem7_tim.c cmem7_uart.c cmem7_usb.c cmem7_wdg.c
  group source/hal/driver/Hercules/cmem7/common/vendor/Driver/inc
    ../../../../source/hal/driver/hercules/cmem7/common/Vendor/Driver/inc/: cmem7.h cmem7_adc.h cmem7_aes.h cmem7_can.h cmem7_conf.h cmem7_ddr.h cmem7_ddr_tuning.h cmem7_dma.h cmem7_efuse.h cmem7_eth.h cmem7_flash.h cmem7_gpio.h cmem7_i2c.h cmem7_includes.h cmem7_misc.h cmem7_retarget.h cmem7_rtc.h cmem7_spi.h cmem7_tim.h cmem7_uart.h cmem7_usb.h cmem7_wdg.h system_cmem7.h
  group source/hal/driver/Hercules/cmem7/common/vendor/CMSIS/CME-M7
    ../../../../source/hal/driver/hercules/cmem7/common/Vendor/CMSIS/CME_M7/: cmem7_it.c cmem7_it.h system_cmem7.c
  group source/hal/driver/Hercules/cmem7/common/vendor/CMSIS/CME_M7/startup/arm
    ../../../../source/hal/driver/hercules/cmem7/common/Vendor/CMSIS/CME_M7/startup/arm/: startup_cmem7.S
  group source/hal/driver/common
    ../../../../source/hal/driver/common/: common.h
  group source/hal/driver/common/spi
    ../../../../source/hal/driver/common/spi/: __spi_cs_common.h
  group source/hal/driver/common/swi
    ../../../../source/hal/driver/common/swi/: vsf_swi_template.h
  group source/hal/driver/common/template
    ../../../../source/hal/driver/common/template/: vsf_template_adc.h vsf_template_hal_driver.h vsf_template_io.h vsf_template_pm.h vsf_template_spi.h vsf_template_usart.h vsf_template_usb.h
  group source/hal/driver/common/usart
    ../../../../source/hal/driver/common/usart/: __usart_common.h vsf_drv_usart_poll_util.h
  group source/hal/driver/template
    ../../../../source/hal/driver/template/: driver.h
  group source/hal/driver/vsf
    ../../../../source/hal/driver/vsf/: driver.h
  group source/hal/driver/vsf/distbus
    ../../../../source/hal/driver/vsf/distbus/: driver.h vsf_hal_distbus.c
  group source/hal/driver/vsf/distbus/usbd
    ../../../../source/hal/driver/vsf/distbus/usbd/: vsf_hal_distbus_usbd.c vsf_hal_distbus_usbd.h
  group source/hal/driver/vsf/gpio/74hc165
    ../../../../source/hal/driver/vsf/gpio/74hc165/: vsf_gpio_74hc165.c vsf_gpio_74hc165.h vsf_gpio_74hc165.c vsf_gpio_74hc165.h
  group source/kernel
    ../../../../source/kernel/: vsf_eda.c vsf_eda.h vsf_eda_slist_queue.c vsf_eda_slist_queue.h vsf_evtq.h vsf_evtq_array.c vsf_evtq_list.c vsf_kernel.h vsf_kernel_bsp.c vsf_kernel_cfg.h vsf_kernel_common.h vsf_os.c vsf_os.h vsf_timq.h vsf_timq_dlist.h
  group source/kernel/__eda
    ../../../../source/kernel/__eda/: vsf_eda_bmpevt.c vsf_eda_queue.c vsf_eda_sync.c vsf_eda_timer.c
  group source/kernel/shell
    ../../../../source/kernel/shell/: vsf_shell.c vsf_shell.h
  group source/kernel/shell/simple
    ../../../../source/kernel/shell/simple/: vsf_simple.h vsf_simple_bmpevt.c vsf_simple_bmpevt.h vsf_simple_task.c
  group source/kernel/task
    ../../../../source/kernel/task/: __vsf_task_common.h vsf_fsm.h vsf_pt.h vsf_task.h vsf_thread.c vsf_thread.h vsf_task.c
  group source/osa_hal
    ../../../../source/osa_hal/: vsf_osa_hal.c vsf_osa_hal.h vsf_osa_hal_cfg.h
  group source/osa_hal/driver
    ../../../../source/osa_hal/driver/: driver.h
  group source/osa_hal/driver/customised
    ../../../../source/osa_hal/driver/customised/: driver.h
  group source/osa_hal/driver/customised/multiplex_hal
    ../../../../source/osa_hal/driver/customised/multiplex_hal/: driver.h vsf_multiplex_hal_common.h
  group source/osa_hal/driver/customised/multiplex_hal/iic
    ../../../../source/osa_hal/driver/customised/multiplex_hal/iic/: vsf_multiplex_iic.c vsf_multiplex_iic.h
  group source/osa_hal/driver/customised/multiplex_hal/spi
    ../../../../source/osa_hal/driver/customised/multiplex_hal/spi/: vsf_multiplex_spi.c vsf_multiplex_spi.h
  group source/osa_hal/driver/customised/stream_hal
    ../../../../source/osa_hal/driver/customised/stream_hal/: driver.h
  group source/osa_hal/driver/customised/stream_hal/usart
    ../../../../source/osa_hal/driver/customised/stream_hal/usart/: vsf_stream_usart.c vsf_stream_usart.h
  group source/osa_hal/sw_peripheral
    ../../../../source/osa_hal/sw_peripheral/: sw_periperhal_cfg.h sw_peripheral.h
  group source/osa_hal/sw_peripheral/io_peripheral
    ../../../../source/osa_hal/sw_peripheral/io_peripheral/: io_periperhal_cfg.h io_peripheral.h
  group source/osa_hal/sw_peripheral/io_peripheral/iic
    ../../../../source/osa_hal/sw_peripheral/io_peripheral/iic/: vsf_io_iic.c vsf_io_iic.h
  group source/osa_hal/sw_peripheral/io_peripheral/spi
    ../../../../source/osa_hal/sw_peripheral/io_peripheral/spi/: vsf_io_spi.c vsf_io_spi.h
  group source/osa_hal/sw_peripheral/sw_peripheral_template
    ../../../../source/osa_hal/sw_peripheral/sw_peripheral_template/: vsf_sw_xxxxxx.c vsf_sw_xxxxxx.h
  group source/osa_service
    ../../../../source/osa_service/: vsf_osa_service.c vsf_osa_service.h vsf_osa_service_cfg.h
  group source/osa_service/msg_tree
    ../../../../source/osa_service/msg_tree/: vsf_msg_tree.c vsf_msg_tree.h
  group source/service
    ../../../../source/service/: vsf_service.c vsf_service.h vsf_service_cfg.h
  group source/service/distbus
    ../../../../source/service/distbus/: vsf_distbus.c vsf_distbus.h
  group source/service/dynarr
    ../../../../source/service/dynarr/: vsf_dynarr.c vsf_dynarr.h
  group source/service/dynstack
    ../../../../source/service/dynstack/: vsf_dynstack.c vsf_dynstack.h
  group source/service/fifo
    ../../../../source/service/fifo/: vsf_fifo.c vsf_fifo.h
  group source/service/heap
    ../../../../source/service/heap/: vsf_heap.c vsf_heap.h
  group source/service/json
    ../../../../source/service/json/: vsf_json.c vsf_json.h
  group source/service/pbuf
    ../../../../source/service/pbuf/: vsf_pbuf.c vsf_pbuf.h vsf_pbuf_pool.c vsf_pbuf_pool.h
  group source/service/pool
    ../../../../source/service/pool/: vsf_pool.c vsf_pool.h
  group source/service/simple_stream
    ../../../../source/service/simple_stream/: vsf_simple_stream.c vsf_simple_stream.h
  group source/service/simple_stream/block_stream
    ../../../../source/service/simple_stream/block_stream/: vsf_block_stream.c vsf_block_stream.h
  group source/service/simple_stream/distbus_stream
    ../../../../source/service/simple_stream/distbus_stream/: vsf_distbus_stream.c vsf_distbus_stream.h
  group source/service/simple_stream/fifo_stream
    ../../../../source/service/simple_stream/fifo_stream/: vsf_fifo_stream.c vsf_fifo_stream.h
  group source/service/simple_stream/mem_stream
    ../../../../source/service/simple_stream/mem_stream/: vsf_mem_stream.c vsf_mem_stream.h
  group source/service/simple_stream/queue_stream
    ../../../../source/service/simple_stream/queue_stream/: vsf_queue_stream.c vsf_queue_stream.h
  group source/service/stream
    ../../../../source/service/stream/: interface.h vsf_stream.c vsf_stream.h vsf_stream_base.c vsf_stream_base.h vsf_stream_reader.c vsf_stream_reader.h vsf_stream_writer.c vsf_stream_writer.h
  group source/service/stream/pbuf_queue
    ../../../../source/service/stream/pbuf_queue/: vsf_pbuf_queue.c vsf_pbuf_queue.h
  group source/service/trace
    ../../../../source/service/trace/: vsf_trace.c vsf_trace.h
  group source/shell
    ../../../../source/shell/: vsf_shell_wrapper.h
  group source/shell/media/sdl2
    ../../../../source/shell/media/sdl2/: vsf_sdl2.c vsf_sdl2_cfg.h vsf_sdl2_event.c vsf_sdl2_pixelformat.c
  group source/shell/media/sdl2/include/SDL2
    ../../../../source/shell/media/sdl2/include/SDL2/: SDL.h SDL_cpuinfo.h SDL_endian.h SDL_events.h SDL_keyboard.h SDL_keycode.h SDL_log.h SDL_mouse.h SDL_mutex.h SDL_rwops.h SDL_stdinc.h SDL_surface.h SDL_thread.h SDL_timer.h SDL_version.h begin_code.h close_code.h
  group source/shell/sys/linux
    ../../../../source/shell/sys/linux/: vsf_linux.c vsf_linux.h vsf_linux_cfg.h
  group source/shell/sys/linux/include
    ../../../../source/shell/sys/linux/include/: dirent.h errno.h fcntl.h libgen.h libusb.h netdb.h poll.h pthread.h pwd.h sched.h semaphore.h signal.h termios.h unistd.h
  group source/shell/sys/linux/include/arpa
    ../../../../source/shell/sys/linux/include/arpa/: inet.h
  group source/shell/sys/linux/include/linux
    ../../../../source/shell/sys/linux/include/linux/: limits.h
  group source/shell/sys/linux/include/netinet
    ../../../../source/shell/sys/linux/include/netinet/: in.h ip.h
  group source/shell/sys/linux/include/simple_libc
    ../../../../source/shell/sys/linux/include/simple_libc/: ctype.h stddef.h stdio.h stdlib.h string.h time.h wchar.h
  group source/shell/sys/linux/include/sys
    ../../../../source/shell/sys/linux/include/sys/: ipc.h mount.h select.h shm.h socket.h stat.h time.h types.h uio.h wait.h
  group source/shell/sys/linux/kernel/fs
    ../../../../source/shell/sys/linux/kernel/fs/: vsf_linux_fs.c vsf_linux_fs.h
  group source/shell/sys/linux/kernel/fs/vfs
    ../../../../source/shell/sys/linux/kernel/fs/vfs/: vsf_linux_vfs.c vsf_linux_vfs.h
  group source/shell/sys/linux/kernel/fs/vfs/devfs
    ../../../../source/shell/sys/linux/kernel/fs/vfs/devfs/: vsf_linux_devfs.c vsf_linux_devfs.h
  group source/shell/sys/linux/kernel/socket
    ../../../../source/shell/sys/linux/kernel/socket/: vsf_linux_socket.c vsf_linux_socket.h
  group source/shell/sys/linux/kernel/socket/inet
    ../../../../source/shell/sys/linux/kernel/socket/inet/: vsf_linux_socket_inet_lwip.c
  group source/shell/sys/linux/kernel/socket/unix
    ../../../../source/shell/sys/linux/kernel/socket/unix/: vsf_linux_socket_unix.c
  group source/shell/sys/linux/lib/glibc
    ../../../../source/shell/sys/linux/lib/glibc/: vsf_linux_glibc.c vsf_linux_glibc_ctype.c vsf_linux_glibc_pthread.c vsf_linux_glibc_sem.c vsf_linux_glibc_stdio.c vsf_linux_glibc_stdlib.c vsf_linux_glibc_string.c vsf_linux_glibc_time.c
  group source/shell/sys/linux/lib/libgen
    ../../../../source/shell/sys/linux/lib/libgen/: vsf_linux_libgen.c
  group source/shell/sys/linux/lib/libusb
    ../../../../source/shell/sys/linux/lib/libusb/: vsf_linux_libusb.c
  group source/shell/sys/linux/port/busybox
    ../../../../source/shell/sys/linux/port/busybox/: busybox.c busybox.h config.h
  group source/shell/sys/linux/port/busybox/shell
    ../../../../source/shell/sys/linux/port/busybox/shell/: vsh.c
  group source/shell/sys/xboot
    ../../../../source/shell/sys/xboot/: vsf_xboot.c vsf_xboot_cfg.h
  group source/shell/sys/xboot/include
    ../../../../source/shell/sys/xboot/include/: io.h stddef.h types.h xboot.h
  group source/shell/sys/xboot/include/arch
    ../../../../source/shell/sys/xboot/include/arch/: atomic.h barrier.h endian.h irqflags.h spinlock.h
  group source/shell/sys/xboot/include/xboot
    ../../../../source/shell/sys/xboot/include/xboot/: window.h
  group source/shell/sys/xboot/include/xfs
    ../../../../source/shell/sys/xboot/include/xfs/: xfs.h
  group source/utilities
    ../../../../source/utilities/: communicate.h ooc_class.h vsf_utilities.h vsf_utilities_cfg.h
  group source/utilities/3rd-party/PLOOC/raw
    ../../../../source/utilities/3rd-party/PLOOC/raw/: plooc.h plooc_class.h plooc_class_black_box.h plooc_class_simple.h plooc_class_simple_c90.h plooc_class_strict.h
  group source/utilities/compiler
    ../../../../source/utilities/compiler/: compiler.h
  group source/utilities/compiler/__common
    ../../../../source/utilities/compiler/__common/: __compiler.h __retarget_io.c __type.h
  group source/utilities/compiler/__common/__retarget_io
    ../../../../source/utilities/compiler/__common/__retarget_io/: __retarget_io_gcc_llvm.c __retarget_io_iar.c
  group source/utilities/compiler/arm
    ../../../../source/utilities/compiler/arm/: arm_compiler.c arm_compiler.h retarget_io.c type.h
  group source/utilities/compiler/default
    ../../../../source/utilities/compiler/default/: default_compiler.h type.h
  group source/utilities/compiler/mcs51
    ../../../../source/utilities/compiler/mcs51/: mcs51_compiler.h mcs51_interrupt.c msc51_interrupt.h retarget_io.c type.h
  group source/utilities/compiler/rv
    ../../../../source/utilities/compiler/rv/: retarget_io.c rv_compiler.h type.h
  group source/utilities/compiler/rv/RISCV
    ../../../../source/utilities/compiler/rv/RISCV/: riscv_compiler.h
  group source/utilities/compiler/rv/RISCV/drivers
    ../../../../source/utilities/compiler/rv/RISCV/drivers/: n200_eclic.h n200_func.c n200_func.h n200_timer.h riscv_bits.h riscv_const.h riscv_encoding.h
  group source/utilities/compiler/x86
    ../../../../source/utilities/compiler/x86/: type.h x86_compiler.c x86_compiler.h
  group source/utilities/language_extension
    ../../../../source/utilities/language_extension/: code_region.c code_region.h delegate.c delegate.h language_extension.h simple_sprintf.c simple_sscanf.c
  group source/utilities/preprocessor
    ../../../../source/utilities/preprocessor/: mf_u8_dec2str.h vsf_connect_macro.h vsf_foreach_macro.h vsf_macro_calc.h vsf_preprocessor.h vsf_repeat_macro.h
  group source/utilities/template
    ../../../../source/utilities/template/: template.h vsf_bitmap.c vsf_bitmap.h vsf_list.c vsf_list.h vsf_queue.c vsf_queue.h
target cmem7 (6160000::V6.16::ARMCLANG)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: vsf_template
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=6 v6LangP=3 wLevel=3
  c define: __Hercules__, __CMEM7__, __M7M12N5__, PRINT_UART=UART0, __OOC_CPP__, LV_CONF_INCLUDE_SIMPLE, FT2_BUILD_LIBRARY
  c misc: as above
  c include: ..\..\config;..\..\config\3rd-party\lvgl;..\..\..\..\source;..\..\..\..\source\shell\sys\linux\include;..\..\..\..\source\shell\sys\linux\include\simple_libc;..\..\..\..\source\shell\sys\linux\kernel\fs\vfs\files\terminfo;..\..\..\..\source\utilities\compiler\arm\3rd-party\CMSIS\CMSIS\Core\Include;..\..\..\..\source\component\3rd-party\nnom\raw\inc;..\..\..\..\source\component\3rd-party\vsfvm\raw;..\..\..\..\source\component\3rd-party\lvgl\raw;..\..\..\..\source\component\3rd-party\segger_rtt\raw;..\..\..\..\source\component\3rd-party\LingLongGUI\port;..\..\..\..\source\component\3rd-party\LingLongGUI\raw\Gui;..\..\..\..\source\component\3rd-party\freetype\port;..\..\..\..\source\component\3rd-party\freetype\raw\include;..\..\..\..\source\component\3rd-party\coremark\port;..\..\..\..\source\component\3rd-party\coremark\raw;..\..\..\..\source\component\3rd-party\lua\extension\oo;..\..\..\..\source\component\3rd-party\lua\extension\lovevsf;..\..\..\..\source\component\3rd-party\lua\raw;..\..\..\..\source\component\3rd-party\libjpeg-turbo\port;..\..\..\..\source\component\3rd-party\libjpeg-turbo\raw;..\..\..\..\source\component\3rd-party\libpng\port;..\..\..\..\source\component\3rd-party\libpng\raw;..\..\..\..\source\component\3rd-party\segger\port\Config;..\..\..\..\source\component\3rd-party\segger\raw\RTT;..\..\..\..\source\component\3rd-party\segger\raw\SystemView;..\..\..\..\source\component\3rd-party\zlib\raw;..\..\..\..\source\component\usb\driver\otg\dwcotg;..\..\..\..\source\hal\driver\hercules\cmem7\common\Vendor\Driver\inc
  asm misc: --cpreproc --cpreproc_opts=-D_MSC_VER,-D__ARM__,-D__MPS2__
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\vsf_template.sct
